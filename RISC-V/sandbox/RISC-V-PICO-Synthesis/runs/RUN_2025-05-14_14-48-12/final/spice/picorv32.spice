* NGSPICE file created from picorv32.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_2 abstract view
.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_4 abstract view
.subckt sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_12 abstract view
.subckt sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41oi_1 abstract view
.subckt sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_2 abstract view
.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_2 abstract view
.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_4 abstract view
.subckt sky130_fd_sc_hd__a221o_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_4 abstract view
.subckt sky130_fd_sc_hd__and4bb_4 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_2 abstract view
.subckt sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

.subckt picorv32 VGND VPWR clk eoi[0] eoi[10] eoi[11] eoi[12] eoi[13] eoi[14] eoi[15]
+ eoi[16] eoi[17] eoi[18] eoi[19] eoi[1] eoi[20] eoi[21] eoi[22] eoi[23] eoi[24] eoi[25]
+ eoi[26] eoi[27] eoi[28] eoi[29] eoi[2] eoi[30] eoi[31] eoi[3] eoi[4] eoi[5] eoi[6]
+ eoi[7] eoi[8] eoi[9] irq[0] irq[10] irq[11] irq[12] irq[13] irq[14] irq[15] irq[16]
+ irq[17] irq[18] irq[19] irq[1] irq[20] irq[21] irq[22] irq[23] irq[24] irq[25] irq[26]
+ irq[27] irq[28] irq[29] irq[2] irq[30] irq[31] irq[3] irq[4] irq[5] irq[6] irq[7]
+ irq[8] irq[9] mem_addr[0] mem_addr[10] mem_addr[11] mem_addr[12] mem_addr[13] mem_addr[14]
+ mem_addr[15] mem_addr[16] mem_addr[17] mem_addr[18] mem_addr[19] mem_addr[1] mem_addr[20]
+ mem_addr[21] mem_addr[22] mem_addr[23] mem_addr[24] mem_addr[25] mem_addr[26] mem_addr[27]
+ mem_addr[28] mem_addr[29] mem_addr[2] mem_addr[30] mem_addr[31] mem_addr[3] mem_addr[4]
+ mem_addr[5] mem_addr[6] mem_addr[7] mem_addr[8] mem_addr[9] mem_instr mem_la_addr[0]
+ mem_la_addr[10] mem_la_addr[11] mem_la_addr[12] mem_la_addr[13] mem_la_addr[14]
+ mem_la_addr[15] mem_la_addr[16] mem_la_addr[17] mem_la_addr[18] mem_la_addr[19]
+ mem_la_addr[1] mem_la_addr[20] mem_la_addr[21] mem_la_addr[22] mem_la_addr[23] mem_la_addr[24]
+ mem_la_addr[25] mem_la_addr[26] mem_la_addr[27] mem_la_addr[28] mem_la_addr[29]
+ mem_la_addr[2] mem_la_addr[30] mem_la_addr[31] mem_la_addr[3] mem_la_addr[4] mem_la_addr[5]
+ mem_la_addr[6] mem_la_addr[7] mem_la_addr[8] mem_la_addr[9] mem_la_read mem_la_wdata[0]
+ mem_la_wdata[10] mem_la_wdata[11] mem_la_wdata[12] mem_la_wdata[13] mem_la_wdata[14]
+ mem_la_wdata[15] mem_la_wdata[16] mem_la_wdata[17] mem_la_wdata[18] mem_la_wdata[19]
+ mem_la_wdata[1] mem_la_wdata[20] mem_la_wdata[21] mem_la_wdata[22] mem_la_wdata[23]
+ mem_la_wdata[24] mem_la_wdata[25] mem_la_wdata[26] mem_la_wdata[27] mem_la_wdata[28]
+ mem_la_wdata[29] mem_la_wdata[2] mem_la_wdata[30] mem_la_wdata[31] mem_la_wdata[3]
+ mem_la_wdata[4] mem_la_wdata[5] mem_la_wdata[6] mem_la_wdata[7] mem_la_wdata[8]
+ mem_la_wdata[9] mem_la_write mem_la_wstrb[0] mem_la_wstrb[1] mem_la_wstrb[2] mem_la_wstrb[3]
+ mem_rdata[0] mem_rdata[10] mem_rdata[11] mem_rdata[12] mem_rdata[13] mem_rdata[14]
+ mem_rdata[15] mem_rdata[16] mem_rdata[17] mem_rdata[18] mem_rdata[19] mem_rdata[1]
+ mem_rdata[20] mem_rdata[21] mem_rdata[22] mem_rdata[23] mem_rdata[24] mem_rdata[25]
+ mem_rdata[26] mem_rdata[27] mem_rdata[28] mem_rdata[29] mem_rdata[2] mem_rdata[30]
+ mem_rdata[31] mem_rdata[3] mem_rdata[4] mem_rdata[5] mem_rdata[6] mem_rdata[7] mem_rdata[8]
+ mem_rdata[9] mem_ready mem_valid mem_wdata[0] mem_wdata[10] mem_wdata[11] mem_wdata[12]
+ mem_wdata[13] mem_wdata[14] mem_wdata[15] mem_wdata[16] mem_wdata[17] mem_wdata[18]
+ mem_wdata[19] mem_wdata[1] mem_wdata[20] mem_wdata[21] mem_wdata[22] mem_wdata[23]
+ mem_wdata[24] mem_wdata[25] mem_wdata[26] mem_wdata[27] mem_wdata[28] mem_wdata[29]
+ mem_wdata[2] mem_wdata[30] mem_wdata[31] mem_wdata[3] mem_wdata[4] mem_wdata[5]
+ mem_wdata[6] mem_wdata[7] mem_wdata[8] mem_wdata[9] mem_wstrb[0] mem_wstrb[1] mem_wstrb[2]
+ mem_wstrb[3] pcpi_insn[0] pcpi_insn[10] pcpi_insn[11] pcpi_insn[12] pcpi_insn[13]
+ pcpi_insn[14] pcpi_insn[15] pcpi_insn[16] pcpi_insn[17] pcpi_insn[18] pcpi_insn[19]
+ pcpi_insn[1] pcpi_insn[20] pcpi_insn[21] pcpi_insn[22] pcpi_insn[23] pcpi_insn[24]
+ pcpi_insn[25] pcpi_insn[26] pcpi_insn[27] pcpi_insn[28] pcpi_insn[29] pcpi_insn[2]
+ pcpi_insn[30] pcpi_insn[31] pcpi_insn[3] pcpi_insn[4] pcpi_insn[5] pcpi_insn[6]
+ pcpi_insn[7] pcpi_insn[8] pcpi_insn[9] pcpi_rd[0] pcpi_rd[10] pcpi_rd[11] pcpi_rd[12]
+ pcpi_rd[13] pcpi_rd[14] pcpi_rd[15] pcpi_rd[16] pcpi_rd[17] pcpi_rd[18] pcpi_rd[19]
+ pcpi_rd[1] pcpi_rd[20] pcpi_rd[21] pcpi_rd[22] pcpi_rd[23] pcpi_rd[24] pcpi_rd[25]
+ pcpi_rd[26] pcpi_rd[27] pcpi_rd[28] pcpi_rd[29] pcpi_rd[2] pcpi_rd[30] pcpi_rd[31]
+ pcpi_rd[3] pcpi_rd[4] pcpi_rd[5] pcpi_rd[6] pcpi_rd[7] pcpi_rd[8] pcpi_rd[9] pcpi_ready
+ pcpi_rs1[0] pcpi_rs1[10] pcpi_rs1[11] pcpi_rs1[12] pcpi_rs1[13] pcpi_rs1[14] pcpi_rs1[15]
+ pcpi_rs1[16] pcpi_rs1[17] pcpi_rs1[18] pcpi_rs1[19] pcpi_rs1[1] pcpi_rs1[20] pcpi_rs1[21]
+ pcpi_rs1[22] pcpi_rs1[23] pcpi_rs1[24] pcpi_rs1[25] pcpi_rs1[26] pcpi_rs1[27] pcpi_rs1[28]
+ pcpi_rs1[29] pcpi_rs1[2] pcpi_rs1[30] pcpi_rs1[31] pcpi_rs1[3] pcpi_rs1[4] pcpi_rs1[5]
+ pcpi_rs1[6] pcpi_rs1[7] pcpi_rs1[8] pcpi_rs1[9] pcpi_rs2[0] pcpi_rs2[10] pcpi_rs2[11]
+ pcpi_rs2[12] pcpi_rs2[13] pcpi_rs2[14] pcpi_rs2[15] pcpi_rs2[16] pcpi_rs2[17] pcpi_rs2[18]
+ pcpi_rs2[19] pcpi_rs2[1] pcpi_rs2[20] pcpi_rs2[21] pcpi_rs2[22] pcpi_rs2[23] pcpi_rs2[24]
+ pcpi_rs2[25] pcpi_rs2[26] pcpi_rs2[27] pcpi_rs2[28] pcpi_rs2[29] pcpi_rs2[2] pcpi_rs2[30]
+ pcpi_rs2[31] pcpi_rs2[3] pcpi_rs2[4] pcpi_rs2[5] pcpi_rs2[6] pcpi_rs2[7] pcpi_rs2[8]
+ pcpi_rs2[9] pcpi_valid pcpi_wait pcpi_wr resetn trace_data[0] trace_data[10] trace_data[11]
+ trace_data[12] trace_data[13] trace_data[14] trace_data[15] trace_data[16] trace_data[17]
+ trace_data[18] trace_data[19] trace_data[1] trace_data[20] trace_data[21] trace_data[22]
+ trace_data[23] trace_data[24] trace_data[25] trace_data[26] trace_data[27] trace_data[28]
+ trace_data[29] trace_data[2] trace_data[30] trace_data[31] trace_data[32] trace_data[33]
+ trace_data[34] trace_data[35] trace_data[3] trace_data[4] trace_data[5] trace_data[6]
+ trace_data[7] trace_data[8] trace_data[9] trace_valid trap
X_05903_ _02084_ _02449_ _02086_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__o21ai_1
XFILLER_100_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_124_2311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06883_ decoded_imm\[21\] net862 VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__or2_1
XFILLER_95_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09671_ net1310 _02596_ net366 VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_124_2322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05834_ _02211_ _02392_ net829 VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_38_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08622_ decoded_imm\[7\] net600 net626 VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__a21o_1
X_05765_ _02153_ _02331_ VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__nor2_1
X_08553_ net668 _04246_ net660 VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__a21oi_1
XFILLER_42_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08484_ net68 net1314 net406 VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__mux2_1
X_07504_ net1482 net328 net426 VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__mux2_1
XFILLER_35_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05696_ _02270_ _02271_ _02163_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__o21ai_1
X_07435_ net1785 net472 net434 VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__mux2_1
XFILLER_22_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_102_1963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_149_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07366_ net492 net1753 net443 VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__mux2_1
XFILLER_149_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09105_ net2147 net499 _04750_ _04754_ VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__a22o_1
X_07297_ net1446 net532 net453 VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__mux2_1
X_06317_ net753 _02749_ _02750_ _02748_ net650 VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_135_2484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09036_ _04696_ _04697_ _04703_ _04704_ net682 net667 VGND VGND VPWR VPWR _04705_
+ sky130_fd_sc_hd__mux4_1
X_06248_ reg_out\[27\] alu_out_q\[27\] net843 VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__mux2_1
XFILLER_136_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_135_2495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold351 cpuregs\[27\]\[20\] VGND VGND VPWR VPWR net1459 sky130_fd_sc_hd__dlygate4sd3_1
Xhold362 cpuregs\[12\]\[19\] VGND VGND VPWR VPWR net1470 sky130_fd_sc_hd__dlygate4sd3_1
Xhold340 cpuregs\[31\]\[13\] VGND VGND VPWR VPWR net1448 sky130_fd_sc_hd__dlygate4sd3_1
X_06179_ _02631_ _02632_ VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__nor2_1
Xhold395 cpuregs\[15\]\[30\] VGND VGND VPWR VPWR net1503 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold373 cpuregs\[23\]\[6\] VGND VGND VPWR VPWR net1481 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold384 cpuregs\[26\]\[2\] VGND VGND VPWR VPWR net1492 sky130_fd_sc_hd__dlygate4sd3_1
X_09938_ clknet_leaf_74_clk _00067_ VGND VGND VPWR VPWR cpuregs\[11\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_104_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout842 net843 VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__buf_4
Xfanout831 instr_sub VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__clkbuf_4
Xfanout820 instr_rdinstr VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__clkbuf_2
Xfanout853 net192 VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__buf_2
Xfanout864 net183 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__buf_2
XFILLER_58_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout875 net172 VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__clkbuf_4
Xhold1040 cpuregs\[4\]\[27\] VGND VGND VPWR VPWR net2148 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1051 cpuregs\[6\]\[19\] VGND VGND VPWR VPWR net2159 sky130_fd_sc_hd__dlygate4sd3_1
X_09869_ decoded_imm_j\[16\] _01110_ net333 VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__mux2_1
Xfanout897 net898 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__buf_4
XFILLER_18_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout886 net182 VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__buf_2
Xhold1062 cpuregs\[16\]\[16\] VGND VGND VPWR VPWR net2170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1073 cpuregs\[5\]\[18\] VGND VGND VPWR VPWR net2181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1084 cpuregs\[9\]\[6\] VGND VGND VPWR VPWR net2192 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold1095 cpuregs\[11\]\[24\] VGND VGND VPWR VPWR net2203 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10713_ clknet_leaf_101_clk _00805_ VGND VGND VPWR VPWR mem_do_wdata sky130_fd_sc_hd__dfxtp_1
X_10644_ clknet_leaf_81_clk _00768_ VGND VGND VPWR VPWR count_cycle\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10575_ clknet_leaf_65_clk _00699_ VGND VGND VPWR VPWR reg_next_pc\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_761 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_75_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11127_ clknet_leaf_15_clk _01168_ VGND VGND VPWR VPWR cpuregs\[31\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_11058_ clknet_leaf_87_clk _01109_ VGND VGND VPWR VPWR mem_rdata_q\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_2030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10009_ clknet_leaf_114_clk _00133_ VGND VGND VPWR VPWR cpuregs\[30\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_898 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05550_ net888 net847 VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__or2_1
XFILLER_60_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05481_ net864 net215 VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__nor2_1
XFILLER_149_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07220_ net1309 net260 net464 VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__mux2_1
XFILLER_20_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07151_ net725 _03552_ _03555_ net519 VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__o211a_1
XFILLER_118_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06102_ _02568_ _02569_ net674 VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__mux2_1
X_07082_ _03485_ _03488_ VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__nand2_1
XFILLER_145_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06033_ mem_rdata_q\[24\] net17 net611 VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__mux2_1
XFILLER_59_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07984_ _03803_ _03804_ VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__nor2_1
X_09723_ net268 net1768 net363 VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__mux2_1
X_06935_ reg_pc\[22\] net561 _03347_ net518 net521 VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__a221o_1
XFILLER_86_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09654_ net276 net2144 net370 VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__mux2_1
XFILLER_103_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06866_ net524 _03279_ _03280_ VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__or3_1
X_05817_ _02076_ _02373_ _02216_ VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__a21o_1
XFILLER_55_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08605_ cpuregs\[20\]\[7\] cpuregs\[21\]\[7\] cpuregs\[22\]\[7\] cpuregs\[23\]\[7\]
+ net942 net907 VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_2_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09585_ net1926 net290 net378 VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__mux2_1
X_06797_ _03211_ _03212_ _03213_ _03214_ net728 net639 VGND VGND VPWR VPWR _03215_
+ sky130_fd_sc_hd__mux4_2
XFILLER_27_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05748_ _02121_ _02316_ VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__nand2_1
X_08536_ decoded_imm\[0\] _04234_ net601 VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__mux2_1
X_08467_ reg_pc\[31\] net562 net522 VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__a21oi_1
X_05679_ _02131_ _02144_ _02143_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__a21bo_1
XFILLER_11_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07418_ net1539 net270 net440 VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_137_2524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08398_ _04144_ _04145_ VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__nor2_1
XFILLER_11_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07349_ net1603 net280 net447 VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__mux2_1
XFILLER_109_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_2735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_2724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10360_ clknet_leaf_136_clk _00484_ VGND VGND VPWR VPWR cpuregs\[25\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10291_ clknet_leaf_69_clk _00415_ VGND VGND VPWR VPWR cpuregs\[15\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_09019_ _04683_ _04684_ net682 VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold170 cpuregs\[14\]\[9\] VGND VGND VPWR VPWR net1278 sky130_fd_sc_hd__dlygate4sd3_1
Xhold181 cpuregs\[4\]\[29\] VGND VGND VPWR VPWR net1289 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 cpuregs\[28\]\[4\] VGND VGND VPWR VPWR net1300 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout650 _01567_ VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_148_2697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout683 net684 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__clkbuf_4
Xfanout661 net662 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__buf_4
XFILLER_93_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout694 mem_wordsize\[2\] VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__buf_4
XFILLER_77_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout672 net676 VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10627_ clknet_leaf_104_clk _00751_ VGND VGND VPWR VPWR count_cycle\[44\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_40_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10558_ clknet_leaf_132_clk _00682_ VGND VGND VPWR VPWR reg_next_pc\[7\] sky130_fd_sc_hd__dfxtp_1
X_10489_ clknet_leaf_86_clk _00613_ VGND VGND VPWR VPWR count_instr\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04981_ net850 net984 cpu_state\[5\] _01605_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__and4b_1
XTAP_TAPCELL_ROW_88_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06720_ _03138_ _03139_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__nand2_1
XFILLER_37_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06651_ net877 net507 net488 _03073_ VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__o211a_1
XFILLER_37_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05602_ net125 net879 VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__and2b_1
X_09370_ net832 decoded_imm_j\[13\] net615 net720 VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__a22o_1
X_06582_ reg_pc\[9\] net560 _03007_ net516 net520 VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__a221o_1
X_05533_ _02110_ _02112_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__nor2_1
X_08321_ count_cycle\[22\] _04095_ net992 VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__o21ai_1
X_08252_ net558 _04051_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__nor2_1
X_05464_ _02039_ _02043_ _02044_ VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__or3_1
XFILLER_32_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07203_ net1437 net337 net462 VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__mux2_1
X_08183_ _03948_ _03986_ _03987_ VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
X_05395_ count_instr\[26\] net821 net623 _01980_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__a211o_1
XFILLER_20_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07134_ net607 _03536_ _03538_ VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__and3_1
X_07065_ _03470_ _03471_ _03472_ net730 net725 VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__a221o_1
XFILLER_134_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput220 net220 VGND VGND VPWR VPWR pcpi_rs2[25] sky130_fd_sc_hd__buf_2
X_06016_ net854 _02510_ net637 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__mux2_1
Xoutput231 net231 VGND VGND VPWR VPWR pcpi_rs2[6] sky130_fd_sc_hd__buf_2
XFILLER_142_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07967_ net688 reg_next_pc\[7\] net545 _03703_ VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__a22o_1
X_06918_ net607 _03329_ _03330_ VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__and3_1
XFILLER_74_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09706_ net470 net1643 net361 VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__mux2_1
X_07898_ _02707_ reg_next_pc\[31\] net575 VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__mux2_2
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06849_ _03258_ _03263_ _03264_ net728 net639 VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__a221o_1
XFILLER_83_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09637_ net493 net2106 net372 VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__mux2_1
XFILLER_70_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09568_ net1453 net537 net380 VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_26_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08519_ cpuregs\[12\]\[0\] cpuregs\[13\]\[0\] cpuregs\[14\]\[0\] cpuregs\[15\]\[0\]
+ net950 net915 VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__mux4_1
XFILLER_129_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09499_ net1253 net238 net391 VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__mux2_1
XFILLER_135_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11461_ clknet_leaf_39_clk _01499_ VGND VGND VPWR VPWR cpuregs\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_10412_ clknet_leaf_37_clk _00536_ VGND VGND VPWR VPWR cpuregs\[20\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_11392_ clknet_leaf_55_clk _01430_ VGND VGND VPWR VPWR cpuregs\[7\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10343_ clknet_leaf_21_clk _00467_ VGND VGND VPWR VPWR cpuregs\[16\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10274_ clknet_leaf_16_clk _00398_ VGND VGND VPWR VPWR cpuregs\[15\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout480 net481 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__buf_4
Xfanout491 _02743_ VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__clkbuf_4
XFILLER_74_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_100_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05180_ _01768_ _01772_ _01781_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__nand3_1
Xhold917 cpuregs\[29\]\[22\] VGND VGND VPWR VPWR net2025 sky130_fd_sc_hd__dlygate4sd3_1
Xhold928 cpuregs\[1\]\[21\] VGND VGND VPWR VPWR net2036 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold906 cpuregs\[22\]\[24\] VGND VGND VPWR VPWR net2014 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_127_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_114_2162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold939 cpuregs\[16\]\[6\] VGND VGND VPWR VPWR net2047 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_124_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08870_ net679 _04547_ VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__or2_1
XFILLER_97_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07821_ _03686_ net1000 _03685_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__and3b_1
XFILLER_85_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07752_ _03642_ _03643_ VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__nor2_1
X_04964_ net621 _01583_ _01590_ VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__or3_1
X_06703_ cpuregs\[28\]\[14\] cpuregs\[29\]\[14\] cpuregs\[30\]\[14\] cpuregs\[31\]\[14\]
+ net793 net757 VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__mux4_1
X_07683_ _03598_ _03599_ VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__nor2_1
X_09422_ net279 net1955 net398 VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__mux2_1
XFILLER_92_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06634_ _03051_ _03052_ net646 VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__mux2_1
X_09353_ decoded_imm\[22\] net554 _04828_ _04838_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_23_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08304_ _04085_ _04086_ VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__nor2_1
X_06565_ _02989_ _02990_ VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__nor2_1
X_05516_ net852 net227 VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__xnor2_2
X_09284_ net1151 net128 net483 VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__mux2_1
X_06496_ cpuregs\[4\]\[6\] cpuregs\[5\]\[6\] cpuregs\[6\]\[6\] cpuregs\[7\]\[6\] net775
+ net739 VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__mux4_1
X_08235_ _04034_ _04035_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__nor2_1
X_05447_ net715 _02027_ _02028_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__and3_1
XFILLER_60_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08166_ net685 _03971_ _03972_ _03970_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__a31o_1
X_05378_ _01962_ _01963_ VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__nand2_1
XFILLER_109_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07117_ cpuregs\[20\]\[29\] cpuregs\[21\]\[29\] cpuregs\[22\]\[29\] cpuregs\[23\]\[29\]
+ net806 net769 VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__mux4_1
XFILLER_119_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08097_ decoded_imm_j\[18\] _03714_ VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__nand2_1
XFILLER_133_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07048_ _03430_ _03432_ _03454_ net610 VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__a31o_1
Xclkload90 clknet_leaf_125_clk VGND VGND VPWR VPWR clkload90/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_102_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_145_2645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08999_ cpuregs\[20\]\[28\] cpuregs\[21\]\[28\] cpuregs\[22\]\[28\] cpuregs\[23\]\[28\]
+ net972 net937 VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__mux4_1
XFILLER_75_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_2656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10961_ clknet_leaf_96_clk _01017_ VGND VGND VPWR VPWR decoded_imm\[13\] sky130_fd_sc_hd__dfxtp_2
XFILLER_18_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_835 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10892_ clknet_leaf_79_clk _00948_ VGND VGND VPWR VPWR cpuregs\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_65_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11444_ clknet_leaf_127_clk _01482_ VGND VGND VPWR VPWR cpuregs\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11375_ clknet_leaf_24_clk _01413_ VGND VGND VPWR VPWR cpuregs\[6\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_10326_ clknet_leaf_64_clk _00450_ VGND VGND VPWR VPWR cpuregs\[26\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10257_ clknet_leaf_65_clk _00381_ VGND VGND VPWR VPWR cpuregs\[27\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10188_ clknet_leaf_34_clk _00312_ VGND VGND VPWR VPWR cpuregs\[9\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06350_ instr_lui is_lui_auipc_jal VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__and2b_1
XFILLER_148_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05301_ _01892_ _01893_ VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__xor2_1
X_06281_ net641 _02711_ _02715_ net722 VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__a211o_1
Xclkbuf_leaf_150_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_150_clk sky130_fd_sc_hd__clkbuf_8
X_05232_ _01828_ _01829_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__nand2_1
X_08020_ _03823_ _03828_ _03836_ net832 VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__o31a_1
Xhold703 cpuregs\[19\]\[16\] VGND VGND VPWR VPWR net1811 sky130_fd_sc_hd__dlygate4sd3_1
Xhold714 cpuregs\[12\]\[27\] VGND VGND VPWR VPWR net1822 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold736 cpuregs\[2\]\[15\] VGND VGND VPWR VPWR net1844 sky130_fd_sc_hd__dlygate4sd3_1
X_05163_ net706 net201 _01763_ net702 _01766_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__a221o_1
Xhold725 cpuregs\[11\]\[3\] VGND VGND VPWR VPWR net1833 sky130_fd_sc_hd__dlygate4sd3_1
Xhold769 cpuregs\[12\]\[25\] VGND VGND VPWR VPWR net1877 sky130_fd_sc_hd__dlygate4sd3_1
Xhold758 cpuregs\[10\]\[22\] VGND VGND VPWR VPWR net1866 sky130_fd_sc_hd__dlygate4sd3_1
X_09971_ clknet_4_12_0_clk _00095_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dfxtp_1
Xhold747 cpuregs\[17\]\[13\] VGND VGND VPWR VPWR net1855 sky130_fd_sc_hd__dlygate4sd3_1
X_05094_ _01701_ VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__inv_2
X_08922_ cpuregs\[12\]\[24\] cpuregs\[13\]\[24\] cpuregs\[14\]\[24\] cpuregs\[15\]\[24\]
+ net971 net936 VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__mux4_1
XFILLER_39_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08853_ net679 _04522_ net892 VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__o21a_1
XFILLER_97_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_127_2364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08784_ _04456_ _04457_ net680 VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__mux2_1
X_05996_ net180 _02500_ net636 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__mux2_2
X_07804_ count_instr\[52\] count_instr\[51\] _03672_ VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__and3_1
XFILLER_84_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07735_ net2314 _03630_ net997 VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__o21ai_1
XFILLER_84_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04947_ net817 net826 net821 VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__nor3_1
XFILLER_26_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_140_2575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07666_ net718 count_instr\[1\] count_instr\[0\] net849 VGND VGND VPWR VPWR _03589_
+ sky130_fd_sc_hd__and4_1
X_09405_ net528 net1580 net400 VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__mux2_1
X_06617_ decoded_imm\[11\] net173 VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__or2_1
X_07597_ net1518 net535 net417 VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__mux2_1
XFILLER_41_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09336_ mem_rdata_q\[30\] net616 VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__and2_1
XFILLER_71_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06548_ cpuregs\[20\]\[8\] cpuregs\[21\]\[8\] cpuregs\[22\]\[8\] cpuregs\[23\]\[8\]
+ net773 net737 VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__mux4_1
X_09267_ _01548_ _01597_ _04805_ net235 VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__a211o_1
X_08218_ net690 reg_next_pc\[27\] net547 _03724_ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_141_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_141_clk sky130_fd_sc_hd__clkbuf_8
X_06479_ decoded_imm\[6\] net879 VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__or2_1
XFILLER_147_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09198_ decoded_imm_j\[14\] _01108_ _02514_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08149_ _03955_ _03956_ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__and2_1
XFILLER_134_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11160_ clknet_leaf_1_clk _01201_ VGND VGND VPWR VPWR cpuregs\[23\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11091_ clknet_leaf_53_clk _01142_ VGND VGND VPWR VPWR cpuregs\[24\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_10111_ clknet_leaf_147_clk _00235_ VGND VGND VPWR VPWR cpuregs\[28\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10042_ clknet_leaf_115_clk _00166_ VGND VGND VPWR VPWR cpuregs\[13\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold41 cpuregs\[0\]\[31\] VGND VGND VPWR VPWR net1149 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 net164 VGND VGND VPWR VPWR net1138 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_152_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold52 net149 VGND VGND VPWR VPWR net1160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 net54 VGND VGND VPWR VPWR net1182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 net41 VGND VGND VPWR VPWR net1171 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_152_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold96 net137 VGND VGND VPWR VPWR net1204 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold85 decoded_rd\[2\] VGND VGND VPWR VPWR net1193 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10944_ clknet_leaf_91_clk _01000_ VGND VGND VPWR VPWR decoded_imm\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10875_ clknet_leaf_7_clk _00931_ VGND VGND VPWR VPWR cpuregs\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_132_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_132_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_145_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_5 _01557_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11427_ clknet_leaf_23_clk _01465_ VGND VGND VPWR VPWR cpuregs\[8\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_78_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_2110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11358_ clknet_leaf_9_clk _01396_ VGND VGND VPWR VPWR cpuregs\[6\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10309_ clknet_leaf_12_clk _00433_ VGND VGND VPWR VPWR cpuregs\[26\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_91_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11289_ clknet_leaf_6_clk _01330_ VGND VGND VPWR VPWR cpuregs\[4\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05850_ _02404_ _02405_ _02407_ VGND VGND VPWR VPWR alu_out\[22\] sky130_fd_sc_hd__o21ai_1
XFILLER_94_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07520_ net1283 net259 net429 VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__mux2_1
X_05781_ _02148_ _02345_ _02346_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__o21a_1
XFILLER_47_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07451_ net1907 net273 net436 VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_122_2283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07382_ net281 net2034 net444 VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06402_ _02805_ _02808_ _02832_ _02833_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_98_1905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09121_ net2362 net548 _04761_ is_lb_lh_lw_lbu_lhu VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__a22o_1
X_06333_ net643 _02766_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_33_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_123_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_123_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_148_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09052_ cpuregs\[8\]\[31\] cpuregs\[9\]\[31\] cpuregs\[10\]\[31\] cpuregs\[11\]\[31\]
+ net965 net930 VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__mux4_1
X_06264_ reg_out\[30\] alu_out_q\[30\] net843 VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__mux2_1
Xhold500 cpuregs\[13\]\[22\] VGND VGND VPWR VPWR net1608 sky130_fd_sc_hd__dlygate4sd3_1
X_06195_ net297 net1727 net478 VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__mux2_1
Xhold511 cpuregs\[13\]\[19\] VGND VGND VPWR VPWR net1619 sky130_fd_sc_hd__dlygate4sd3_1
X_05215_ count_cycle\[12\] net617 net589 _01814_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__o211a_1
X_08003_ _03821_ _03822_ net976 VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__o21a_1
XFILLER_150_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold544 cpuregs\[29\]\[31\] VGND VGND VPWR VPWR net1652 sky130_fd_sc_hd__dlygate4sd3_1
Xhold522 cpuregs\[26\]\[14\] VGND VGND VPWR VPWR net1630 sky130_fd_sc_hd__dlygate4sd3_1
X_05146_ count_instr\[39\] net815 net819 count_instr\[7\] VGND VGND VPWR VPWR _01751_
+ sky130_fd_sc_hd__a22o_1
Xhold533 cpuregs\[12\]\[0\] VGND VGND VPWR VPWR net1641 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_795 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold577 cpuregs\[31\]\[30\] VGND VGND VPWR VPWR net1685 sky130_fd_sc_hd__dlygate4sd3_1
Xhold566 cpuregs\[31\]\[27\] VGND VGND VPWR VPWR net1674 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold588 cpuregs\[20\]\[15\] VGND VGND VPWR VPWR net1696 sky130_fd_sc_hd__dlygate4sd3_1
Xhold555 cpuregs\[6\]\[7\] VGND VGND VPWR VPWR net1663 sky130_fd_sc_hd__dlygate4sd3_1
Xhold599 cpuregs\[30\]\[10\] VGND VGND VPWR VPWR net1707 sky130_fd_sc_hd__dlygate4sd3_1
X_09954_ clknet_leaf_135_clk _00078_ VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dfxtp_2
X_05077_ count_cycle\[2\] net617 VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__or2_1
X_08905_ net680 _04580_ VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__or2_1
Xhold1200 count_instr\[62\] VGND VGND VPWR VPWR net2308 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09885_ net1114 VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__clkbuf_1
X_08836_ _04514_ _04515_ net678 VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__mux2_1
Xhold1222 decoded_imm_j\[13\] VGND VGND VPWR VPWR net2330 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1211 instr_sw VGND VGND VPWR VPWR net2319 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1233 instr_and VGND VGND VPWR VPWR net2341 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_58_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_142_2604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1255 _00855_ VGND VGND VPWR VPWR net2363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1244 decoded_imm_j\[7\] VGND VGND VPWR VPWR net2352 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1266 net196 VGND VGND VPWR VPWR net2374 sky130_fd_sc_hd__dlygate4sd3_1
X_08767_ net673 _04445_ _04444_ net659 VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__o211a_1
X_05979_ reg_out\[10\] reg_next_pc\[10\] net569 VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__mux2_1
XFILLER_26_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07718_ count_instr\[20\] _03618_ count_instr\[21\] VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__a21o_1
XFILLER_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08698_ net672 _04384_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__or2_1
X_07649_ net280 net1711 net412 VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__mux2_1
XFILLER_53_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10660_ clknet_leaf_134_clk _04884_ VGND VGND VPWR VPWR reg_out\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_62_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09319_ latched_rd\[1\] _04818_ _04819_ net1188 VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__a22o_1
XFILLER_40_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10591_ clknet_leaf_107_clk _00715_ VGND VGND VPWR VPWR count_cycle\[8\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_114_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_114_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_22_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_153_2799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_420 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11212_ clknet_leaf_24_clk _01253_ VGND VGND VPWR VPWR cpuregs\[29\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput42 net42 VGND VGND VPWR VPWR mem_addr[17] sky130_fd_sc_hd__buf_2
X_11143_ clknet_leaf_50_clk _01184_ VGND VGND VPWR VPWR cpuregs\[31\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xoutput53 net53 VGND VGND VPWR VPWR mem_addr[28] sky130_fd_sc_hd__buf_2
Xoutput75 net75 VGND VGND VPWR VPWR mem_la_addr[19] sky130_fd_sc_hd__buf_2
Xoutput64 net64 VGND VGND VPWR VPWR mem_addr[9] sky130_fd_sc_hd__buf_2
XFILLER_1_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11074_ clknet_leaf_87_clk _01125_ VGND VGND VPWR VPWR mem_rdata_q\[31\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_73_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput97 net847 VGND VGND VPWR VPWR mem_la_wdata[0] sky130_fd_sc_hd__buf_2
Xoutput86 net86 VGND VGND VPWR VPWR mem_la_addr[2] sky130_fd_sc_hd__buf_2
X_10025_ clknet_leaf_27_clk _00149_ VGND VGND VPWR VPWR cpuregs\[30\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_19_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_481 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10927_ clknet_leaf_32_clk _00983_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dfxtp_1
XFILLER_16_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10858_ clknet_leaf_98_clk net2240 VGND VGND VPWR VPWR is_sll_srl_sra sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_105_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_105_clk sky130_fd_sc_hd__clkbuf_8
X_10789_ clknet_leaf_98_clk _00848_ VGND VGND VPWR VPWR instr_bne sky130_fd_sc_hd__dfxtp_1
XFILLER_9_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05000_ instr_slt net1415 instr_blt VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__or3_1
XFILLER_125_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout309 net311 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__clkbuf_2
X_06951_ cpuregs\[12\]\[23\] cpuregs\[13\]\[23\] cpuregs\[14\]\[23\] cpuregs\[15\]\[23\]
+ net800 net763 VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__mux4_1
XFILLER_101_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05902_ _02247_ _02452_ _02453_ _02447_ VGND VGND VPWR VPWR alu_out\[28\] sky130_fd_sc_hd__a31o_1
XFILLER_95_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09670_ net1513 net529 net366 VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__mux2_1
XFILLER_39_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_124_2312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06882_ net306 _03282_ _03296_ _03269_ VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__a31o_1
X_08621_ _04311_ _04312_ net482 _04309_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_124_2323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05833_ _02062_ _02387_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_38_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05764_ _02154_ net578 net584 VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__o21ba_1
X_08552_ _00010_ _04249_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__nand2_1
XFILLER_63_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08483_ net67 net1177 net406 VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__mux2_1
X_07503_ net1705 net335 net426 VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__mux2_1
XFILLER_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05695_ _02168_ _02269_ net828 VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__a21oi_1
X_07434_ net1450 net475 net434 VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__mux2_1
XFILLER_149_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07365_ _02591_ net1942 net443 VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__mux2_1
XFILLER_148_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09104_ net720 net721 mem_rdata_q\[14\] VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__nor3b_2
X_07296_ net1919 net537 net453 VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__mux2_1
X_06316_ cpuregs\[11\]\[1\] net790 net753 VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__a21bo_1
X_06247_ net258 net1720 net479 VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__mux2_1
X_09035_ cpuregs\[0\]\[30\] cpuregs\[1\]\[30\] cpuregs\[2\]\[30\] cpuregs\[3\]\[30\]
+ net974 net939 VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_135_2496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold341 cpuregs\[30\]\[20\] VGND VGND VPWR VPWR net1449 sky130_fd_sc_hd__dlygate4sd3_1
X_06178_ reg_pc\[13\] reg_pc\[12\] _02624_ VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__and3_1
Xhold330 cpuregs\[2\]\[2\] VGND VGND VPWR VPWR net1438 sky130_fd_sc_hd__dlygate4sd3_1
Xhold352 cpuregs\[25\]\[2\] VGND VGND VPWR VPWR net1460 sky130_fd_sc_hd__dlygate4sd3_1
Xhold363 cpuregs\[14\]\[25\] VGND VGND VPWR VPWR net1471 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_120_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold385 cpuregs\[26\]\[18\] VGND VGND VPWR VPWR net1493 sky130_fd_sc_hd__dlygate4sd3_1
X_05129_ net887 net698 _01734_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__and3_1
Xhold396 cpuregs\[23\]\[13\] VGND VGND VPWR VPWR net1504 sky130_fd_sc_hd__dlygate4sd3_1
Xhold374 cpuregs\[26\]\[9\] VGND VGND VPWR VPWR net1482 sky130_fd_sc_hd__dlygate4sd3_1
X_09937_ clknet_leaf_71_clk _00066_ VGND VGND VPWR VPWR cpuregs\[11\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_104_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout843 latched_stalu VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__buf_4
XFILLER_89_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout821 net823 VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__buf_2
Xfanout832 net833 VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__buf_2
Xfanout810 is_beq_bne_blt_bge_bltu_bgeu VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__buf_2
Xfanout854 net191 VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__buf_2
Xfanout865 net866 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__clkbuf_2
Xfanout876 net202 VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__buf_2
XFILLER_133_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout898 _00010_ VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__buf_4
X_09868_ decoded_imm_j\[15\] _01109_ net332 VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__mux2_1
XFILLER_58_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout887 net888 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__buf_2
Xhold1041 cpuregs\[8\]\[2\] VGND VGND VPWR VPWR net2149 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1030 cpuregs\[22\]\[5\] VGND VGND VPWR VPWR net2138 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1063 cpuregs\[7\]\[29\] VGND VGND VPWR VPWR net2171 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1052 cpuregs\[17\]\[22\] VGND VGND VPWR VPWR net2160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1085 cpuregs\[20\]\[30\] VGND VGND VPWR VPWR net2193 sky130_fd_sc_hd__dlygate4sd3_1
X_08819_ _04497_ _04498_ net677 VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__mux2_1
Xhold1074 instr_sltu VGND VGND VPWR VPWR net2182 sky130_fd_sc_hd__dlygate4sd3_1
X_09799_ net540 net2174 net349 VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__mux2_1
Xhold1096 cpuregs\[19\]\[30\] VGND VGND VPWR VPWR net2204 sky130_fd_sc_hd__dlygate4sd3_1
X_10712_ clknet_leaf_101_clk _00804_ VGND VGND VPWR VPWR mem_do_rdata sky130_fd_sc_hd__dfxtp_1
XFILLER_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10643_ clknet_leaf_81_clk _00767_ VGND VGND VPWR VPWR count_cycle\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10574_ clknet_leaf_65_clk _00698_ VGND VGND VPWR VPWR reg_next_pc\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_773 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_122_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11126_ clknet_leaf_151_clk _01167_ VGND VGND VPWR VPWR cpuregs\[31\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_77_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11057_ clknet_leaf_102_clk _01108_ VGND VGND VPWR VPWR mem_rdata_q\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_2031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10008_ clknet_leaf_137_clk _00132_ VGND VGND VPWR VPWR cpuregs\[30\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_36_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05480_ net864 net215 VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__and2_1
XFILLER_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07150_ net643 _03553_ _03554_ _03546_ net640 VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__a221o_1
X_07081_ _03486_ _03487_ VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__nand2_1
X_06101_ cpuregs\[16\]\[4\] cpuregs\[17\]\[4\] cpuregs\[18\]\[4\] cpuregs\[19\]\[4\]
+ net953 net918 VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__mux4_1
XFILLER_145_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06032_ decoded_imm_j\[3\] _01117_ net330 VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__mux2_1
XFILLER_59_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09722_ net272 net1890 net363 VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__mux2_1
XFILLER_87_638 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07983_ decoded_imm_j\[9\] _03705_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__nor2_1
X_06934_ _03343_ _03344_ _03346_ _03345_ net729 net724 VGND VGND VPWR VPWR _03347_
+ sky130_fd_sc_hd__mux4_2
XFILLER_101_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09653_ net280 net1758 net370 VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__mux2_1
XFILLER_95_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06865_ net865 net509 _03200_ net497 VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__o211a_1
XFILLER_28_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05816_ net542 _02375_ _02377_ VGND VGND VPWR VPWR alu_out\[18\] sky130_fd_sc_hd__o21ai_1
X_09584_ net1863 net293 net378 VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__mux2_1
XFILLER_83_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08604_ net125 net630 _04295_ _04296_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06796_ _03207_ _03208_ net651 VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__mux2_1
X_08535_ _02527_ _04233_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__nor2_1
X_05747_ net828 _02122_ _02315_ _02314_ VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__o31ai_1
XFILLER_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08466_ net639 _04185_ _04199_ _02722_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__a211o_1
X_05678_ net544 _02255_ _02256_ _02252_ VGND VGND VPWR VPWR alu_out\[1\] sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_42_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07417_ net1517 net274 net440 VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_137_2525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08397_ net2333 _04143_ net996 VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__o21ai_1
X_07348_ net1779 net285 net447 VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__mux2_1
XFILLER_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_150_2736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_2725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07279_ net1479 net292 net456 VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__mux2_1
XFILLER_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10290_ clknet_leaf_49_clk _00414_ VGND VGND VPWR VPWR cpuregs\[15\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_09018_ net682 _04678_ net894 VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__o21a_1
XFILLER_151_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold160 cpuregs\[31\]\[29\] VGND VGND VPWR VPWR net1268 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold171 cpuregs\[21\]\[11\] VGND VGND VPWR VPWR net1279 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 cpuregs\[28\]\[24\] VGND VGND VPWR VPWR net1290 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold193 cpuregs\[14\]\[1\] VGND VGND VPWR VPWR net1301 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout651 net657 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout640 _01569_ VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_148_2698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout684 _01555_ VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__clkbuf_4
Xfanout662 net663 VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout673 net676 VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__clkbuf_2
Xfanout695 mem_wordsize\[2\] VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__clkbuf_2
XFILLER_73_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_146_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10626_ clknet_leaf_104_clk _00750_ VGND VGND VPWR VPWR count_cycle\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_40_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10557_ clknet_leaf_127_clk _00681_ VGND VGND VPWR VPWR reg_next_pc\[6\] sky130_fd_sc_hd__dfxtp_1
X_10488_ clknet_leaf_86_clk _00612_ VGND VGND VPWR VPWR count_instr\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_142_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04980_ mem_do_prefetch _01603_ VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__nand2_1
XFILLER_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11109_ clknet_leaf_130_clk _00006_ VGND VGND VPWR VPWR reg_sh\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_88_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06650_ net870 net513 VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__or2_1
XFILLER_64_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05601_ net878 net844 VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__nand2b_1
XFILLER_80_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06581_ _03003_ _03004_ _03005_ _03006_ net726 net638 VGND VGND VPWR VPWR _03007_
+ sky130_fd_sc_hd__mux4_2
X_05532_ net870 net210 VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__nor2_1
X_08320_ _04095_ _04096_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__nor2_1
X_08251_ net839 _04049_ _04050_ _04048_ VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__o31a_1
X_05463_ net703 net343 _02040_ net708 net852 VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__a32o_1
XFILLER_60_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07202_ net1322 net341 net462 VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__mux2_1
X_08182_ _03718_ _03719_ _03720_ _03721_ net812 VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__o41a_1
X_05394_ count_instr\[58\] net816 net826 count_cycle\[58\] VGND VGND VPWR VPWR _01980_
+ sky130_fd_sc_hd__a22o_1
XFILLER_134_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07133_ _03537_ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__inv_2
Xoutput210 net210 VGND VGND VPWR VPWR pcpi_rs2[16] sky130_fd_sc_hd__buf_2
X_07064_ _03461_ _03462_ net656 VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__mux2_1
XFILLER_134_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput221 net221 VGND VGND VPWR VPWR pcpi_rs2[26] sky130_fd_sc_hd__buf_2
X_06015_ reg_out\[28\] reg_next_pc\[28\] net575 VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__mux2_1
Xoutput232 net232 VGND VGND VPWR VPWR pcpi_rs2[7] sky130_fd_sc_hd__buf_2
XFILLER_58_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07966_ _03785_ _03788_ net558 VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__a21oi_1
XFILLER_114_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06917_ _03302_ _03327_ _03328_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__or3b_1
XFILLER_68_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09705_ net473 net1494 net361 VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__mux2_1
XFILLER_28_502 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07897_ reg_pc\[30\] net505 _03727_ net605 VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_94_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_94_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_83_641 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09636_ net528 net2185 net372 VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__mux2_1
X_06848_ _03261_ _03262_ net652 VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06779_ _03170_ _03195_ VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__nor2_1
XFILLER_70_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09567_ net1490 net540 net377 VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__mux2_1
X_09498_ net1658 net239 net392 VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__mux2_1
XFILLER_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08518_ cpuregs\[8\]\[0\] cpuregs\[9\]\[0\] cpuregs\[10\]\[0\] cpuregs\[11\]\[0\]
+ net950 net915 VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__mux4_1
X_08449_ cpuregs\[0\]\[31\] cpuregs\[1\]\[31\] cpuregs\[2\]\[31\] cpuregs\[3\]\[31\]
+ net792 net756 VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__mux4_1
XFILLER_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11460_ clknet_leaf_37_clk _01498_ VGND VGND VPWR VPWR cpuregs\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_10411_ clknet_leaf_20_clk _00535_ VGND VGND VPWR VPWR cpuregs\[20\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_11391_ clknet_leaf_12_clk _01429_ VGND VGND VPWR VPWR cpuregs\[7\]\[15\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10342_ clknet_leaf_28_clk _00466_ VGND VGND VPWR VPWR cpuregs\[16\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10273_ clknet_leaf_2_clk _00397_ VGND VGND VPWR VPWR cpuregs\[15\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_132_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout481 _04264_ VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout470 net471 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__clkbuf_2
XFILLER_19_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout492 net493 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_85_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_85_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10609_ clknet_leaf_89_clk _00733_ VGND VGND VPWR VPWR count_cycle\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold918 cpuregs\[28\]\[21\] VGND VGND VPWR VPWR net2026 sky130_fd_sc_hd__dlygate4sd3_1
Xhold907 cpuregs\[17\]\[1\] VGND VGND VPWR VPWR net2015 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_2163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_2152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold929 cpuregs\[6\]\[18\] VGND VGND VPWR VPWR net2037 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07820_ count_instr\[58\] count_instr\[57\] _03682_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__and3_1
X_07751_ count_instr\[32\] _03641_ net992 VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__o21ai_1
Xclkbuf_leaf_76_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_76_clk sky130_fd_sc_hd__clkbuf_8
X_06702_ cpuregs\[24\]\[14\] cpuregs\[25\]\[14\] cpuregs\[26\]\[14\] cpuregs\[27\]\[14\]
+ net781 net745 VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__mux4_1
X_04963_ _01585_ _01586_ _01588_ _01589_ VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__or4_1
XFILLER_38_844 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07682_ net2281 _03597_ net981 VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__o21ai_1
X_09421_ net286 net1851 net398 VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__mux2_1
X_06633_ _03053_ _03054_ net731 VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__mux2_1
X_09352_ mem_rdata_q\[22\] net616 VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__and2_1
X_06564_ _02959_ _02963_ _02988_ net609 VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__a31o_1
X_05515_ _02093_ _02094_ VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__nand2b_1
XFILLER_80_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08303_ net2248 _04084_ net987 VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_23_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09283_ net1180 net127 net483 VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__mux2_1
X_06495_ cpuregs\[20\]\[6\] cpuregs\[21\]\[6\] cpuregs\[22\]\[6\] cpuregs\[23\]\[6\]
+ net777 net741 VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__mux4_1
X_08234_ net814 _03726_ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__nor2_1
X_05446_ _02024_ _02025_ _02026_ _02013_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__a211o_1
XFILLER_119_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08165_ _03941_ _03720_ _03719_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__nand3b_1
X_05377_ _01963_ VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__inv_2
X_07116_ cpuregs\[16\]\[29\] cpuregs\[17\]\[29\] cpuregs\[18\]\[29\] cpuregs\[19\]\[29\]
+ net806 net769 VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__mux4_1
XFILLER_109_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload80 clknet_leaf_48_clk VGND VGND VPWR VPWR clkload80/Y sky130_fd_sc_hd__clkinv_8
XFILLER_109_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08096_ net991 _03908_ VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__and2_1
XFILLER_133_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07047_ _03430_ _03432_ _03454_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__a21oi_1
Xclkload91 clknet_leaf_126_clk VGND VGND VPWR VPWR clkload91/X sky130_fd_sc_hd__clkbuf_8
XFILLER_88_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08998_ cpuregs\[0\]\[28\] cpuregs\[1\]\[28\] cpuregs\[2\]\[28\] cpuregs\[3\]\[28\]
+ net972 net937 VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_145_2646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_67_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_67_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_87_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07949_ _03771_ _03772_ VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__nor2_1
XFILLER_141_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10960_ clknet_leaf_93_clk _01016_ VGND VGND VPWR VPWR decoded_imm\[14\] sky130_fd_sc_hd__dfxtp_2
XFILLER_71_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10891_ clknet_leaf_76_clk _00947_ VGND VGND VPWR VPWR cpuregs\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_09619_ net284 net2017 net375 VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__mux2_1
XFILLER_83_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_880 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11443_ clknet_leaf_123_clk _01481_ VGND VGND VPWR VPWR cpuregs\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11374_ clknet_leaf_74_clk _01412_ VGND VGND VPWR VPWR cpuregs\[6\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10325_ clknet_leaf_75_clk _00449_ VGND VGND VPWR VPWR cpuregs\[26\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_140_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10256_ clknet_leaf_52_clk _00380_ VGND VGND VPWR VPWR cpuregs\[27\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10187_ clknet_leaf_23_clk _00311_ VGND VGND VPWR VPWR cpuregs\[9\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_58_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_58_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_93_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_62_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05300_ reg_pc\[18\] decoded_imm\[18\] _01883_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__a21oi_1
X_06280_ net732 _02714_ _02713_ net727 VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__o211a_1
X_05231_ reg_pc\[14\] decoded_imm\[14\] VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__nand2_1
XFILLER_116_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold715 cpuregs\[10\]\[26\] VGND VGND VPWR VPWR net1823 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold726 cpuregs\[17\]\[17\] VGND VGND VPWR VPWR net1834 sky130_fd_sc_hd__dlygate4sd3_1
X_05162_ count_cycle\[8\] net617 net592 _01765_ VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__o211a_1
Xhold704 cpuregs\[6\]\[12\] VGND VGND VPWR VPWR net1812 sky130_fd_sc_hd__dlygate4sd3_1
Xhold737 cpuregs\[24\]\[3\] VGND VGND VPWR VPWR net1845 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09970_ clknet_leaf_60_clk _00094_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dfxtp_2
Xhold748 cpuregs\[29\]\[13\] VGND VGND VPWR VPWR net1856 sky130_fd_sc_hd__dlygate4sd3_1
Xhold759 cpuregs\[5\]\[10\] VGND VGND VPWR VPWR net1867 sky130_fd_sc_hd__dlygate4sd3_1
X_05093_ reg_pc\[4\] decoded_imm\[4\] VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__nand2_1
X_08921_ net904 _04595_ VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__or2_1
XFILLER_69_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08852_ cpuregs\[8\]\[20\] cpuregs\[9\]\[20\] cpuregs\[10\]\[20\] cpuregs\[11\]\[20\]
+ net959 net924 VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__mux4_1
XFILLER_97_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07803_ count_instr\[51\] _03672_ count_instr\[52\] VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__a21o_1
XFILLER_57_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_49_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_49_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_127_2365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08783_ net680 _04463_ net661 VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__o21a_1
X_05995_ reg_out\[18\] reg_next_pc\[18\] net574 VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__mux2_1
XFILLER_73_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07734_ count_instr\[26\] count_instr\[25\] count_instr\[24\] _03626_ VGND VGND VPWR
+ VPWR _03632_ sky130_fd_sc_hd__and4_1
XFILLER_72_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04946_ net977 net717 VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__nand2_1
XFILLER_26_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07665_ net718 count_instr\[0\] net848 count_instr\[1\] VGND VGND VPWR VPWR _03588_
+ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_140_2576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06616_ decoded_imm\[11\] net173 VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__nand2_1
X_09404_ net530 net1846 net400 VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__mux2_1
XFILLER_26_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07596_ net2010 net539 net414 VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__mux2_1
X_09335_ mem_rdata_q\[31\] net616 net554 net401 _04829_ VGND VGND VPWR VPWR _00999_
+ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_47_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06547_ cpuregs\[16\]\[8\] cpuregs\[17\]\[8\] cpuregs\[18\]\[8\] cpuregs\[19\]\[8\]
+ net774 net738 VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__mux4_1
X_09266_ net235 _01597_ _04805_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__or3_1
X_06478_ net2197 _02907_ net304 VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__mux2_1
XFILLER_138_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08217_ net557 _04019_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__nor2_1
X_05429_ reg_pc\[29\] decoded_imm\[29\] VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__nor2_1
X_09197_ net2330 _01107_ net333 VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_60_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08148_ net812 _03719_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__or2_1
X_08079_ _03713_ _03887_ VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__nand2_1
XFILLER_20_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11090_ clknet_leaf_17_clk _01141_ VGND VGND VPWR VPWR cpuregs\[24\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_10110_ clknet_leaf_144_clk _00234_ VGND VGND VPWR VPWR cpuregs\[28\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_103_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10041_ clknet_leaf_119_clk _00165_ VGND VGND VPWR VPWR cpuregs\[13\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold31 net162 VGND VGND VPWR VPWR net1139 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 cpuregs\[0\]\[7\] VGND VGND VPWR VPWR net1128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 net45 VGND VGND VPWR VPWR net1172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 net148 VGND VGND VPWR VPWR net1161 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_76_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold42 reg_next_pc\[1\] VGND VGND VPWR VPWR net1150 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_152_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold97 cpuregs\[1\]\[29\] VGND VGND VPWR VPWR net1205 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 net156 VGND VGND VPWR VPWR net1183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 net43 VGND VGND VPWR VPWR net1194 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10943_ clknet_leaf_91_clk _00999_ VGND VGND VPWR VPWR decoded_imm\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_56_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10874_ clknet_leaf_7_clk _00930_ VGND VGND VPWR VPWR cpuregs\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_6 _01570_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11426_ clknet_leaf_25_clk _01464_ VGND VGND VPWR VPWR cpuregs\[8\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_2111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11357_ clknet_leaf_8_clk _01395_ VGND VGND VPWR VPWR cpuregs\[6\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10308_ clknet_leaf_4_clk _00432_ VGND VGND VPWR VPWR cpuregs\[26\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11288_ clknet_leaf_5_clk _01329_ VGND VGND VPWR VPWR cpuregs\[4\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10239_ clknet_leaf_148_clk _00363_ VGND VGND VPWR VPWR cpuregs\[27\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_109_2073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05780_ _02148_ _02345_ net543 VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_739 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07450_ net1447 net277 net436 VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_122_2284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07381_ net283 net2091 net444 VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__mux2_1
X_06401_ decoded_imm\[3\] net882 VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__or2_1
X_09120_ net548 _04753_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__nor2_1
X_06332_ net734 _02765_ _02764_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_33_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09051_ cpuregs\[12\]\[31\] cpuregs\[13\]\[31\] cpuregs\[14\]\[31\] cpuregs\[15\]\[31\]
+ net959 net924 VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_98_1906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06263_ net245 net2177 net479 VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__mux2_1
X_08002_ net688 reg_next_pc\[10\] net545 _03706_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06194_ _02643_ _02644_ net567 VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__mux2_1
Xhold501 cpuregs\[30\]\[14\] VGND VGND VPWR VPWR net1609 sky130_fd_sc_hd__dlygate4sd3_1
X_05214_ count_instr\[12\] net819 net625 _01813_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__a211o_1
XFILLER_144_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold545 cpuregs\[17\]\[23\] VGND VGND VPWR VPWR net1653 sky130_fd_sc_hd__dlygate4sd3_1
Xhold534 cpuregs\[30\]\[24\] VGND VGND VPWR VPWR net1642 sky130_fd_sc_hd__dlygate4sd3_1
Xhold512 cpuregs\[30\]\[21\] VGND VGND VPWR VPWR net1620 sky130_fd_sc_hd__dlygate4sd3_1
X_05145_ _01749_ VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__inv_2
Xhold523 cpuregs\[29\]\[9\] VGND VGND VPWR VPWR net1631 sky130_fd_sc_hd__dlygate4sd3_1
Xhold556 cpuregs\[20\]\[21\] VGND VGND VPWR VPWR net1664 sky130_fd_sc_hd__dlygate4sd3_1
Xhold567 cpuregs\[22\]\[30\] VGND VGND VPWR VPWR net1675 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold578 cpuregs\[5\]\[7\] VGND VGND VPWR VPWR net1686 sky130_fd_sc_hd__dlygate4sd3_1
Xhold589 cpuregs\[7\]\[25\] VGND VGND VPWR VPWR net1697 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09953_ clknet_leaf_136_clk _00077_ VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dfxtp_2
X_05076_ count_instr\[34\] net815 net622 _01685_ VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__a211o_1
X_08904_ cpuregs\[12\]\[23\] cpuregs\[13\]\[23\] cpuregs\[14\]\[23\] cpuregs\[15\]\[23\]
+ net966 net931 VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__mux4_1
X_09884_ net1130 VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__clkbuf_1
XFILLER_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08835_ cpuregs\[16\]\[19\] cpuregs\[17\]\[19\] cpuregs\[18\]\[19\] cpuregs\[19\]\[19\]
+ net961 net926 VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__mux4_1
Xhold1234 instr_xori VGND VGND VPWR VPWR net2342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1201 count_cycle\[45\] VGND VGND VPWR VPWR net2309 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1212 count_instr\[44\] VGND VGND VPWR VPWR net2320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1223 count_cycle\[36\] VGND VGND VPWR VPWR net2331 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_142_2605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1256 count_instr\[24\] VGND VGND VPWR VPWR net2364 sky130_fd_sc_hd__dlygate4sd3_1
X_08766_ _04439_ _04448_ _04449_ net659 net897 VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__a221o_1
Xhold1267 instr_jalr VGND VGND VPWR VPWR net2375 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1245 mem_rdata_q\[4\] VGND VGND VPWR VPWR net2353 sky130_fd_sc_hd__dlygate4sd3_1
X_07717_ net2233 _03618_ _03620_ VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_49_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05978_ net202 _02491_ net634 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__mux2_1
XFILLER_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04929_ net173 VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__inv_2
X_08697_ cpuregs\[20\]\[12\] cpuregs\[21\]\[12\] cpuregs\[22\]\[12\] cpuregs\[23\]\[12\]
+ net946 net911 VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__mux4_1
XFILLER_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07648_ net285 net2141 net412 VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__mux2_1
XFILLER_53_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07579_ net1577 net293 net420 VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09318_ latched_rd\[0\] _04818_ _04819_ net1156 VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__a22o_1
X_10590_ clknet_leaf_107_clk _00714_ VGND VGND VPWR VPWR count_cycle\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09249_ net1465 net271 net404 VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_153_2789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11211_ clknet_leaf_73_clk _01252_ VGND VGND VPWR VPWR cpuregs\[29\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11142_ clknet_leaf_66_clk _01183_ VGND VGND VPWR VPWR cpuregs\[31\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xoutput43 net43 VGND VGND VPWR VPWR mem_addr[18] sky130_fd_sc_hd__buf_2
XFILLER_150_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput54 net54 VGND VGND VPWR VPWR mem_addr[29] sky130_fd_sc_hd__buf_2
Xoutput76 net76 VGND VGND VPWR VPWR mem_la_addr[20] sky130_fd_sc_hd__buf_2
Xoutput65 net65 VGND VGND VPWR VPWR mem_instr sky130_fd_sc_hd__buf_2
Xoutput87 net87 VGND VGND VPWR VPWR mem_la_addr[30] sky130_fd_sc_hd__buf_2
X_11073_ clknet_leaf_93_clk _01124_ VGND VGND VPWR VPWR mem_rdata_q\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_73_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput98 net98 VGND VGND VPWR VPWR mem_la_wdata[10] sky130_fd_sc_hd__buf_2
X_10024_ clknet_leaf_45_clk _00148_ VGND VGND VPWR VPWR cpuregs\[30\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10926_ clknet_leaf_37_clk _00982_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dfxtp_1
XFILLER_72_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10857_ clknet_leaf_103_clk _00915_ VGND VGND VPWR VPWR is_sb_sh_sw sky130_fd_sc_hd__dfxtp_2
XFILLER_31_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_30_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10788_ clknet_leaf_97_clk _00847_ VGND VGND VPWR VPWR instr_beq sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_93_1825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11409_ clknet_leaf_118_clk _01447_ VGND VGND VPWR VPWR cpuregs\[8\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06950_ cpuregs\[28\]\[23\] cpuregs\[29\]\[23\] cpuregs\[30\]\[23\] cpuregs\[31\]\[23\]
+ net799 net762 VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__mux4_1
XFILLER_113_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05901_ _02087_ _02451_ VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__or2_1
X_06881_ reg_pc\[20\] net561 _03295_ net518 net521 VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__a221o_1
XFILLER_95_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05832_ _02247_ _02389_ _02391_ VGND VGND VPWR VPWR alu_out\[20\] sky130_fd_sc_hd__a21o_1
X_08620_ net889 _04310_ net664 VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_124_2313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_38_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05763_ net544 _02327_ _02328_ _02330_ VGND VGND VPWR VPWR alu_out\[12\] sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_59_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08551_ _04247_ _04248_ net675 VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__mux2_1
XFILLER_63_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05694_ net828 _02187_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__and2_1
X_08482_ net66 net1210 net406 VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__mux2_1
X_07502_ net1760 net341 net426 VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__mux2_1
X_07433_ net1581 net494 net435 VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__mux2_1
XFILLER_149_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_1965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09103_ net2349 net499 _04750_ _04752_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__a22o_1
X_07364_ net532 net1629 net443 VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__mux2_1
XFILLER_149_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06315_ cpuregs\[8\]\[1\] cpuregs\[9\]\[1\] net790 VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__mux2_1
X_07295_ net1974 net540 net450 VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__mux2_1
X_09034_ cpuregs\[4\]\[30\] cpuregs\[5\]\[30\] cpuregs\[6\]\[30\] cpuregs\[7\]\[30\]
+ net974 net939 VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__mux4_1
X_06246_ _02685_ _02686_ net567 VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_135_2497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_68_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold320 cpuregs\[12\]\[9\] VGND VGND VPWR VPWR net1428 sky130_fd_sc_hd__dlygate4sd3_1
Xhold353 cpuregs\[30\]\[26\] VGND VGND VPWR VPWR net1461 sky130_fd_sc_hd__dlygate4sd3_1
Xhold331 cpuregs\[26\]\[27\] VGND VGND VPWR VPWR net1439 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06177_ reg_pc\[12\] _02623_ reg_pc\[13\] VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__a21oi_1
Xhold342 cpuregs\[27\]\[5\] VGND VGND VPWR VPWR net1450 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout800 net801 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__buf_4
XFILLER_132_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05128_ net6 net24 net885 VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__mux2_1
Xhold364 cpuregs\[22\]\[2\] VGND VGND VPWR VPWR net1472 sky130_fd_sc_hd__dlygate4sd3_1
Xhold386 cpuregs\[5\]\[5\] VGND VGND VPWR VPWR net1494 sky130_fd_sc_hd__dlygate4sd3_1
Xhold375 cpuregs\[28\]\[11\] VGND VGND VPWR VPWR net1483 sky130_fd_sc_hd__dlygate4sd3_1
X_09936_ clknet_leaf_71_clk _00065_ VGND VGND VPWR VPWR cpuregs\[11\]\[28\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout822 net823 VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__clkbuf_2
Xfanout833 net834 VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__clkbuf_2
Xfanout811 is_slli_srli_srai VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__buf_2
X_05059_ count_instr\[1\] net820 count_cycle\[33\] net824 VGND VGND VPWR VPWR _01670_
+ sky130_fd_sc_hd__a22o_1
Xhold397 cpuregs\[23\]\[11\] VGND VGND VPWR VPWR net1505 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout855 net190 VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__buf_2
Xfanout866 net181 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__buf_2
XFILLER_58_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout844 net126 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__buf_4
Xhold1031 cpuregs\[10\]\[30\] VGND VGND VPWR VPWR net2139 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_86_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09867_ decoded_imm_j\[19\] _01113_ net332 VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__mux2_1
Xhold1042 cpuregs\[3\]\[15\] VGND VGND VPWR VPWR net2150 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout888 net171 VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__buf_2
Xfanout877 net201 VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__buf_2
Xhold1020 cpuregs\[21\]\[1\] VGND VGND VPWR VPWR net2128 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout899 net901 VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_4
Xhold1064 cpuregs\[10\]\[25\] VGND VGND VPWR VPWR net2172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1075 cpuregs\[8\]\[30\] VGND VGND VPWR VPWR net2183 sky130_fd_sc_hd__dlygate4sd3_1
X_08818_ net677 _04489_ net893 VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_77_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1053 cpuregs\[6\]\[10\] VGND VGND VPWR VPWR net2161 sky130_fd_sc_hd__dlygate4sd3_1
X_09798_ _02578_ _03561_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__or2_4
Xhold1086 cpuregs\[8\]\[26\] VGND VGND VPWR VPWR net2194 sky130_fd_sc_hd__dlygate4sd3_1
X_08749_ net900 _04429_ _04428_ net660 VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__o211a_1
Xhold1097 instr_lb VGND VGND VPWR VPWR net2205 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_14_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10711_ clknet_leaf_100_clk _00803_ VGND VGND VPWR VPWR mem_do_rinst sky130_fd_sc_hd__dfxtp_2
XFILLER_13_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10642_ clknet_leaf_81_clk _00766_ VGND VGND VPWR VPWR count_cycle\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_127_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10573_ clknet_leaf_65_clk _00697_ VGND VGND VPWR VPWR reg_next_pc\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_127_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_86_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_75_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11125_ clknet_leaf_150_clk _01166_ VGND VGND VPWR VPWR cpuregs\[31\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11056_ clknet_leaf_97_clk _01107_ VGND VGND VPWR VPWR mem_rdata_q\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10007_ clknet_leaf_24_clk _00131_ VGND VGND VPWR VPWR cpuregs\[12\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_103_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_2021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10909_ clknet_leaf_6_clk _00965_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dfxtp_1
XFILLER_60_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_146_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07080_ decoded_imm\[28\] net854 VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__nand2_1
X_06100_ cpuregs\[20\]\[4\] cpuregs\[21\]\[4\] cpuregs\[22\]\[4\] cpuregs\[23\]\[4\]
+ net953 net918 VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__mux4_1
XFILLER_146_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06031_ mem_rdata_q\[23\] net16 net611 VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__mux2_1
X_07982_ decoded_imm_j\[9\] _03705_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__and2_1
X_06933_ _03337_ _03338_ net654 VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__mux2_1
X_09721_ net275 net1701 net363 VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__mux2_1
X_06864_ net870 net509 net489 _03278_ VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__o211a_1
X_09652_ net285 net1936 net370 VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__mux2_1
X_09583_ net1559 net298 net378 VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__mux2_1
XFILLER_103_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05815_ _02073_ net581 _02376_ _02074_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__o22a_1
X_06795_ _03203_ _03204_ net651 VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__mux2_1
XFILLER_82_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08603_ decoded_imm\[6\] net600 net626 VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__a21o_1
X_05746_ _02123_ _02308_ VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__nor2_1
X_08534_ net659 _04220_ _04224_ _04231_ _04232_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__a32o_1
X_08465_ net728 _04198_ _04192_ net724 VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__o211a_1
XFILLER_51_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05677_ net831 _01561_ _02254_ VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_42_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07416_ net1848 net277 net440 VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__mux2_1
X_08396_ count_cycle\[49\] count_cycle\[50\] _04140_ VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__and3_1
XFILLER_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07347_ net1313 net288 net448 VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__mux2_1
XFILLER_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_2737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_2726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09017_ cpuregs\[8\]\[29\] cpuregs\[9\]\[29\] cpuregs\[10\]\[29\] cpuregs\[11\]\[29\]
+ net973 net938 VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__mux4_1
X_07278_ net1267 net295 net457 VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__mux2_1
XFILLER_151_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06229_ reg_pc\[23\] _02669_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__xor2_1
XFILLER_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold150 cpuregs\[21\]\[24\] VGND VGND VPWR VPWR net1258 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold161 cpuregs\[13\]\[4\] VGND VGND VPWR VPWR net1269 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 cpuregs\[27\]\[9\] VGND VGND VPWR VPWR net1291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold172 cpuregs\[30\]\[9\] VGND VGND VPWR VPWR net1280 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 cpuregs\[30\]\[11\] VGND VGND VPWR VPWR net1302 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout641 net643 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__buf_4
Xfanout630 net631 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__clkbuf_4
XFILLER_144_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout685 _01552_ VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__buf_2
Xfanout652 net657 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__buf_2
Xfanout663 _01557_ VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_70_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout674 net676 VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__buf_4
X_09919_ clknet_leaf_4_clk _00048_ VGND VGND VPWR VPWR cpuregs\[11\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_148_2699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout696 net699 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10625_ clknet_leaf_106_clk _00749_ VGND VGND VPWR VPWR count_cycle\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_128_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10556_ clknet_leaf_127_clk _00680_ VGND VGND VPWR VPWR reg_next_pc\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_143_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10487_ clknet_leaf_89_clk _00611_ VGND VGND VPWR VPWR count_instr\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11108_ clknet_leaf_131_clk _00005_ VGND VGND VPWR VPWR reg_sh\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11039_ clknet_leaf_92_clk _00033_ VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__dfxtp_1
XFILLER_65_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05600_ net844 net878 VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__and2b_1
X_06580_ _02995_ _02996_ net644 VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__mux2_1
X_05531_ net870 net210 VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__nand2_1
X_08250_ _03726_ _04027_ _03727_ VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__a21oi_1
X_05462_ count_cycle\[31\] net618 net591 _02042_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_119_2234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08181_ _03943_ _03957_ _03966_ _03977_ VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__and4_1
X_07201_ net1304 net471 net462 VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__mux2_1
X_07132_ _03511_ _03535_ _03534_ _03533_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__o211a_1
X_05393_ net19 net596 net587 VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__a21o_1
XFILLER_146_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07063_ net655 _03468_ net642 VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_132_2445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput200 net200 VGND VGND VPWR VPWR pcpi_rs1[7] sky130_fd_sc_hd__buf_2
Xoutput222 net222 VGND VGND VPWR VPWR pcpi_rs2[27] sky130_fd_sc_hd__buf_2
XFILLER_145_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06014_ net190 _02509_ net636 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__mux2_1
Xoutput211 net211 VGND VGND VPWR VPWR pcpi_rs2[17] sky130_fd_sc_hd__buf_2
Xoutput233 net233 VGND VGND VPWR VPWR pcpi_rs2[8] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_151_Right_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07965_ net834 _03786_ _03787_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__or3b_1
X_06916_ _03298_ _03304_ _03327_ VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_52_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09704_ net494 net2068 net362 VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__mux2_1
XFILLER_28_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07896_ _02701_ reg_next_pc\[30\] net575 VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__mux2_2
XFILLER_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09635_ net530 net1472 net372 VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__mux2_1
X_06847_ net652 _03256_ net642 VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__o21a_1
XFILLER_83_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06778_ _03168_ _03172_ _03195_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__nand3_1
XFILLER_71_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09566_ _03563_ _03567_ VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__nor2_1
XFILLER_43_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09497_ net1369 net244 net392 VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__mux2_1
XFILLER_70_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05729_ _02137_ net577 net583 VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__a21oi_1
X_08517_ net850 net979 _01601_ _01605_ _04216_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_26_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08448_ net759 _04179_ _04180_ _04181_ net735 VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__o221a_1
XFILLER_23_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10410_ clknet_leaf_34_clk _00534_ VGND VGND VPWR VPWR cpuregs\[20\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_08379_ count_cycle\[43\] _04130_ count_cycle\[44\] VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__a21o_1
X_11390_ clknet_leaf_29_clk _01428_ VGND VGND VPWR VPWR cpuregs\[7\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10341_ clknet_leaf_10_clk _00465_ VGND VGND VPWR VPWR cpuregs\[16\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10272_ clknet_leaf_150_clk _00396_ VGND VGND VPWR VPWR cpuregs\[15\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout460 _03568_ VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__clkbuf_8
XFILLER_65_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout471 _02604_ VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__buf_2
Xfanout482 _04264_ VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__buf_4
Xfanout493 net494 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__buf_2
XFILLER_93_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10608_ clknet_leaf_88_clk _00732_ VGND VGND VPWR VPWR count_cycle\[25\] sky130_fd_sc_hd__dfxtp_1
Xhold919 cpuregs\[8\]\[31\] VGND VGND VPWR VPWR net2027 sky130_fd_sc_hd__dlygate4sd3_1
X_10539_ clknet_leaf_60_clk _00663_ VGND VGND VPWR VPWR reg_pc\[19\] sky130_fd_sc_hd__dfxtp_1
Xhold908 cpuregs\[9\]\[14\] VGND VGND VPWR VPWR net2016 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_114_2153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07750_ count_instr\[32\] count_instr\[31\] count_instr\[30\] _03637_ VGND VGND VPWR
+ VPWR _03642_ sky130_fd_sc_hd__and4_2
X_04962_ instr_or instr_sra instr_srl instr_xor VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__or4_1
X_06701_ net175 net510 _03046_ net497 VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__o211a_1
XFILLER_38_856 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07681_ count_instr\[7\] count_instr\[6\] count_instr\[5\] _03593_ VGND VGND VPWR
+ VPWR _03598_ sky130_fd_sc_hd__and4_1
X_09420_ net288 net1888 net398 VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__mux2_1
XFILLER_37_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06632_ cpuregs\[0\]\[11\] cpuregs\[1\]\[11\] cpuregs\[2\]\[11\] cpuregs\[3\]\[11\]
+ net778 net742 VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__mux4_1
X_09351_ decoded_imm\[23\] net554 _04828_ _04837_ VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__o22a_1
X_06563_ _02959_ _02963_ _02988_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_32_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05514_ net857 net220 VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__nand2_1
X_08302_ count_cycle\[13\] count_cycle\[14\] count_cycle\[15\] _04080_ VGND VGND VPWR
+ VPWR _04085_ sky130_fd_sc_hd__and4_1
X_09282_ net1138 net844 net483 VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_23_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08233_ net814 _03726_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__and2_1
XFILLER_100_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06494_ cpuregs\[16\]\[6\] cpuregs\[17\]\[6\] cpuregs\[18\]\[6\] cpuregs\[19\]\[6\]
+ net777 net741 VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__mux4_1
X_05445_ _02013_ _02026_ _02025_ _02024_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__o211ai_1
X_08164_ _03718_ _03719_ _03936_ _03720_ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__a31o_1
X_05376_ reg_pc\[25\] decoded_imm\[25\] VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__nand2_1
X_07115_ cpuregs\[8\]\[29\] cpuregs\[9\]\[29\] cpuregs\[10\]\[29\] cpuregs\[11\]\[29\]
+ net805 net768 VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__mux4_1
XFILLER_109_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08095_ net559 _03906_ _03907_ VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__a21o_1
XFILLER_133_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload70 clknet_leaf_55_clk VGND VGND VPWR VPWR clkload70/Y sky130_fd_sc_hd__clkinv_4
X_07046_ _03452_ _03453_ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_41_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload81 clknet_leaf_50_clk VGND VGND VPWR VPWR clkload81/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_54_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload92 clknet_leaf_128_clk VGND VGND VPWR VPWR clkload92/X sky130_fd_sc_hd__clkbuf_8
XFILLER_125_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08997_ cpuregs\[4\]\[28\] cpuregs\[5\]\[28\] cpuregs\[6\]\[28\] cpuregs\[7\]\[28\]
+ net972 net937 VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__mux4_1
XFILLER_85_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_2658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07948_ _03757_ _03760_ VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__nor2_1
X_07879_ reg_pc\[21\] net504 _03718_ net604 VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__a22o_1
XFILLER_55_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10890_ clknet_leaf_71_clk _00946_ VGND VGND VPWR VPWR cpuregs\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_09618_ net287 net2095 net375 VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__mux2_1
XFILLER_71_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09549_ net1371 net300 net382 VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_892 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11442_ clknet_leaf_121_clk _01480_ VGND VGND VPWR VPWR cpuregs\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_11373_ clknet_leaf_72_clk _01411_ VGND VGND VPWR VPWR cpuregs\[6\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_10324_ clknet_leaf_76_clk _00448_ VGND VGND VPWR VPWR cpuregs\[26\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10255_ clknet_leaf_45_clk _00379_ VGND VGND VPWR VPWR cpuregs\[27\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10186_ clknet_leaf_34_clk _00310_ VGND VGND VPWR VPWR cpuregs\[9\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout290 _02653_ VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05230_ reg_pc\[14\] decoded_imm\[14\] VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__or2_1
XFILLER_30_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05161_ count_instr\[8\] net819 net622 _01764_ VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_96_1867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold716 cpuregs\[24\]\[15\] VGND VGND VPWR VPWR net1824 sky130_fd_sc_hd__dlygate4sd3_1
Xhold727 cpuregs\[12\]\[2\] VGND VGND VPWR VPWR net1835 sky130_fd_sc_hd__dlygate4sd3_1
Xhold705 cpuregs\[1\]\[4\] VGND VGND VPWR VPWR net1813 sky130_fd_sc_hd__dlygate4sd3_1
Xhold749 cpuregs\[28\]\[19\] VGND VGND VPWR VPWR net1857 sky130_fd_sc_hd__dlygate4sd3_1
Xhold738 cpuregs\[18\]\[2\] VGND VGND VPWR VPWR net1846 sky130_fd_sc_hd__dlygate4sd3_1
X_05092_ net711 _01693_ _01700_ VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__a21o_1
XFILLER_131_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08920_ cpuregs\[8\]\[24\] cpuregs\[9\]\[24\] cpuregs\[10\]\[24\] cpuregs\[11\]\[24\]
+ net965 net930 VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__mux4_1
XFILLER_103_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08851_ net679 _04529_ VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__or2_1
XFILLER_97_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_907 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07802_ net2260 _03672_ _03674_ VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__a21oi_1
XFILLER_57_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05994_ net869 _02499_ net637 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__mux2_1
X_08782_ net903 _04464_ VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__or2_1
XFILLER_38_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_2366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07733_ _03630_ _03631_ VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__nor2_1
X_04945_ net977 net717 VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__and2_1
XFILLER_26_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07664_ net2361 net559 _03587_ VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_140_2566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06615_ _01559_ net304 VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__nor2_1
X_09403_ net534 net1815 net400 VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__mux2_1
XFILLER_37_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_140_2577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07595_ _03561_ _03571_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__nor2_1
XFILLER_34_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09334_ decoded_imm\[31\] net553 VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__or2_1
XFILLER_80_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06546_ net731 _02972_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__or2_1
X_09265_ _01571_ _01597_ net612 _04804_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__o31ai_1
X_06477_ net523 _02882_ _02884_ _02886_ _02906_ VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__o41a_1
X_08216_ _04018_ _04017_ _04011_ _04010_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__o2bb2a_1
X_05428_ net715 _02005_ _02011_ VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__a21o_1
X_09196_ decoded_imm_j\[12\] _01106_ net333 VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__mux2_1
XFILLER_107_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_60_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08147_ net812 _03719_ VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__nand2_1
X_05359_ _01926_ _01938_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__nor2_1
XFILLER_106_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08078_ net991 _03891_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__and2_1
X_07029_ cpuregs\[12\]\[26\] cpuregs\[13\]\[26\] cpuregs\[14\]\[26\] cpuregs\[15\]\[26\]
+ net803 net766 VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__mux4_1
XFILLER_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10040_ clknet_leaf_137_clk _00164_ VGND VGND VPWR VPWR cpuregs\[13\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold10 cpuregs\[0\]\[26\] VGND VGND VPWR VPWR net1118 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold32 cpuregs\[0\]\[14\] VGND VGND VPWR VPWR net1140 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 cpuregs\[0\]\[4\] VGND VGND VPWR VPWR net1129 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold65 net44 VGND VGND VPWR VPWR net1173 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold54 net136 VGND VGND VPWR VPWR net1162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 net166 VGND VGND VPWR VPWR net1151 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 net50 VGND VGND VPWR VPWR net1195 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_152_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_707 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold76 instr_beq VGND VGND VPWR VPWR net1184 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 net63 VGND VGND VPWR VPWR net1206 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10942_ clknet_leaf_131_clk _00998_ VGND VGND VPWR VPWR reg_sh\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10873_ clknet_leaf_4_clk _00929_ VGND VGND VPWR VPWR cpuregs\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_43_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11425_ clknet_leaf_25_clk _01463_ VGND VGND VPWR VPWR cpuregs\[8\]\[17\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_7 _01612_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_111_2112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11356_ clknet_leaf_6_clk _01394_ VGND VGND VPWR VPWR cpuregs\[6\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10307_ clknet_leaf_4_clk _00431_ VGND VGND VPWR VPWR cpuregs\[26\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_11287_ clknet_leaf_15_clk _01328_ VGND VGND VPWR VPWR cpuregs\[4\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_91_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10238_ clknet_leaf_146_clk _00362_ VGND VGND VPWR VPWR cpuregs\[27\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10169_ clknet_leaf_118_clk _00293_ VGND VGND VPWR VPWR cpuregs\[9\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_109_2074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_122_2285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06400_ decoded_imm\[3\] net882 VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_106_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07380_ net289 net2158 net444 VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__mux2_1
XFILLER_16_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06331_ cpuregs\[28\]\[1\] cpuregs\[29\]\[1\] cpuregs\[30\]\[1\] cpuregs\[31\]\[1\]
+ net788 net752 VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_33_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06262_ _02696_ _02699_ net568 VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__mux2_1
X_09050_ cpuregs\[0\]\[31\] cpuregs\[1\]\[31\] cpuregs\[2\]\[31\] cpuregs\[3\]\[31\]
+ net959 net924 VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_98_1907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05213_ count_instr\[44\] net818 net827 count_cycle\[44\] VGND VGND VPWR VPWR _01813_
+ sky130_fd_sc_hd__a22o_1
X_08001_ net558 _03820_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__nor2_1
Xhold502 cpuregs\[21\]\[29\] VGND VGND VPWR VPWR net1610 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_129_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06193_ reg_pc\[16\] _02640_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__xor2_1
Xhold513 cpuregs\[2\]\[24\] VGND VGND VPWR VPWR net1621 sky130_fd_sc_hd__dlygate4sd3_1
Xhold524 cpuregs\[9\]\[15\] VGND VGND VPWR VPWR net1632 sky130_fd_sc_hd__dlygate4sd3_1
X_05144_ net16 _01656_ net130 net30 _01748_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__a221oi_4
Xhold535 cpuregs\[5\]\[6\] VGND VGND VPWR VPWR net1643 sky130_fd_sc_hd__dlygate4sd3_1
Xhold557 cpuregs\[23\]\[23\] VGND VGND VPWR VPWR net1665 sky130_fd_sc_hd__dlygate4sd3_1
Xhold568 cpuregs\[28\]\[22\] VGND VGND VPWR VPWR net1676 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold579 cpuregs\[22\]\[13\] VGND VGND VPWR VPWR net1687 sky130_fd_sc_hd__dlygate4sd3_1
X_05075_ count_instr\[2\] net819 count_cycle\[34\] net824 VGND VGND VPWR VPWR _01685_
+ sky130_fd_sc_hd__a22o_1
Xhold546 cpuregs\[18\]\[9\] VGND VGND VPWR VPWR net1654 sky130_fd_sc_hd__dlygate4sd3_1
X_09952_ clknet_leaf_141_clk _00076_ VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dfxtp_2
X_08903_ cpuregs\[0\]\[23\] cpuregs\[1\]\[23\] cpuregs\[2\]\[23\] cpuregs\[3\]\[23\]
+ net966 net931 VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__mux4_1
XFILLER_106_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09883_ net1128 VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__clkbuf_1
XFILLER_112_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08834_ cpuregs\[20\]\[19\] cpuregs\[21\]\[19\] cpuregs\[22\]\[19\] cpuregs\[23\]\[19\]
+ net961 net926 VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__mux4_1
Xhold1224 mem_state\[1\] VGND VGND VPWR VPWR net2332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1213 count_instr\[35\] VGND VGND VPWR VPWR net2321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1202 count_cycle\[6\] VGND VGND VPWR VPWR net2310 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_142_2606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1235 count_instr\[25\] VGND VGND VPWR VPWR net2343 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1246 decoded_imm\[16\] VGND VGND VPWR VPWR net2354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1257 decoded_imm\[15\] VGND VGND VPWR VPWR net2365 sky130_fd_sc_hd__dlygate4sd3_1
X_08765_ _04446_ _04447_ net673 VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__mux2_1
X_07716_ net2233 _03618_ net997 VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__o21ai_1
X_05977_ reg_out\[9\] reg_next_pc\[9\] net569 VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__mux2_1
Xhold1268 decoded_imm\[6\] VGND VGND VPWR VPWR net2376 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_49_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08696_ net205 net630 _04382_ _04383_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_49_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04928_ net880 VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__inv_2
X_07647_ net287 net1831 net412 VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__mux2_1
XFILLER_81_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07578_ net1735 net298 net420 VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__mux2_1
XFILLER_81_795 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09317_ net712 net603 VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__and2b_1
X_06529_ net523 _02941_ _02942_ _02956_ net304 VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_11_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09248_ net2036 net275 net404 VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_153_2779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09179_ mem_rdata_q\[0\] mem_rdata_q\[1\] mem_rdata_q\[2\] mem_rdata_q\[3\] VGND
+ VGND VPWR VPWR _04791_ sky130_fd_sc_hd__and4_1
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_147_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11210_ clknet_leaf_79_clk _01251_ VGND VGND VPWR VPWR cpuregs\[29\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_135_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11141_ clknet_leaf_51_clk _01182_ VGND VGND VPWR VPWR cpuregs\[31\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput44 net44 VGND VGND VPWR VPWR mem_addr[19] sky130_fd_sc_hd__buf_2
Xoutput66 net66 VGND VGND VPWR VPWR mem_la_addr[10] sky130_fd_sc_hd__buf_2
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput55 net55 VGND VGND VPWR VPWR mem_addr[2] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR mem_la_addr[21] sky130_fd_sc_hd__buf_2
Xoutput88 net88 VGND VGND VPWR VPWR mem_la_addr[31] sky130_fd_sc_hd__buf_2
XFILLER_89_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11072_ clknet_leaf_93_clk _01123_ VGND VGND VPWR VPWR mem_rdata_q\[29\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_73_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput99 net99 VGND VGND VPWR VPWR mem_la_wdata[11] sky130_fd_sc_hd__buf_2
XFILLER_49_715 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10023_ clknet_leaf_16_clk _00147_ VGND VGND VPWR VPWR cpuregs\[30\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10925_ clknet_leaf_8_clk _00981_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dfxtp_1
XFILLER_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_795 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10856_ clknet_leaf_98_clk _00914_ VGND VGND VPWR VPWR is_jalr_addi_slti_sltiu_xori_ori_andi
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10787_ clknet_leaf_103_clk _00846_ VGND VGND VPWR VPWR instr_jal sky130_fd_sc_hd__dfxtp_1
XFILLER_9_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11408_ clknet_leaf_137_clk _01446_ VGND VGND VPWR VPWR cpuregs\[8\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_11339_ clknet_leaf_74_clk _01380_ VGND VGND VPWR VPWR cpuregs\[5\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06880_ _03291_ _03292_ _03294_ _03293_ net728 net724 VGND VGND VPWR VPWR _03295_
+ sky130_fd_sc_hd__mux4_2
X_05900_ _02087_ _02451_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__nand2_1
X_05831_ _02060_ net580 net576 _02062_ _02390_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_124_2314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_38_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05762_ _02157_ net579 net577 _02159_ _02329_ VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__a221o_1
XFILLER_54_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08550_ cpuregs\[24\]\[1\] cpuregs\[25\]\[1\] cpuregs\[26\]\[1\] cpuregs\[27\]\[1\]
+ net955 net920 VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__mux4_1
X_05693_ _02127_ _02257_ _02167_ _02126_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__o211ai_1
X_08481_ net95 net1198 net406 VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__mux2_1
X_07501_ net1790 net471 net426 VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__mux2_1
XFILLER_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07432_ net1399 net528 net435 VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_102_1966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09102_ net719 _04751_ VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__or2_1
XFILLER_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07363_ net534 net1774 net443 VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__mux2_1
XFILLER_31_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07294_ _03561_ _03563_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__nor2_1
X_06314_ net790 cpuregs\[10\]\[1\] VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__and2b_1
XFILLER_136_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09033_ cpuregs\[20\]\[30\] cpuregs\[21\]\[30\] cpuregs\[22\]\[30\] cpuregs\[23\]\[30\]
+ net974 net939 VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__mux4_1
X_06245_ reg_pc\[26\] _02682_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__xor2_1
Xhold310 cpuregs\[27\]\[26\] VGND VGND VPWR VPWR net1418 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_135_2498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06176_ reg_out\[13\] alu_out_q\[13\] net840 VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__mux2_1
XFILLER_144_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold332 cpuregs\[29\]\[26\] VGND VGND VPWR VPWR net1440 sky130_fd_sc_hd__dlygate4sd3_1
Xhold321 cpuregs\[23\]\[30\] VGND VGND VPWR VPWR net1429 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold343 cpuregs\[26\]\[20\] VGND VGND VPWR VPWR net1451 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05127_ net711 _01732_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__nand2_1
Xhold376 cpuregs\[14\]\[28\] VGND VGND VPWR VPWR net1484 sky130_fd_sc_hd__dlygate4sd3_1
Xhold387 cpuregs\[5\]\[24\] VGND VGND VPWR VPWR net1495 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold365 cpuregs\[23\]\[5\] VGND VGND VPWR VPWR net1473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold354 cpuregs\[23\]\[0\] VGND VGND VPWR VPWR net1462 sky130_fd_sc_hd__dlygate4sd3_1
X_09935_ clknet_leaf_68_clk _00064_ VGND VGND VPWR VPWR cpuregs\[11\]\[27\] sky130_fd_sc_hd__dfxtp_1
Xfanout801 net802 VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__clkbuf_4
Xfanout812 net813 VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__buf_2
Xfanout823 instr_rdinstr VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__buf_2
Xfanout834 net835 VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__buf_2
Xhold398 cpuregs\[4\]\[14\] VGND VGND VPWR VPWR net1506 sky130_fd_sc_hd__dlygate4sd3_1
X_05058_ net9 _01656_ net130 net12 _01668_ VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__a221o_1
XFILLER_131_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout856 net189 VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__buf_2
Xfanout867 net180 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__buf_2
X_09866_ decoded_imm_j\[4\] _01118_ net331 VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__mux2_1
Xfanout845 net124 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__buf_4
XFILLER_133_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08817_ cpuregs\[0\]\[18\] cpuregs\[1\]\[18\] cpuregs\[2\]\[18\] cpuregs\[3\]\[18\]
+ net959 net924 VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__mux4_1
Xhold1010 cpuregs\[3\]\[17\] VGND VGND VPWR VPWR net2118 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1032 cpuregs\[16\]\[12\] VGND VGND VPWR VPWR net2140 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout889 net890 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__buf_4
Xfanout878 net200 VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__buf_2
Xhold1021 cpuregs\[9\]\[8\] VGND VGND VPWR VPWR net2129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1065 cpuregs\[3\]\[28\] VGND VGND VPWR VPWR net2173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1054 cpuregs\[10\]\[31\] VGND VGND VPWR VPWR net2162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1043 cpuregs\[10\]\[18\] VGND VGND VPWR VPWR net2151 sky130_fd_sc_hd__dlygate4sd3_1
X_09797_ net236 net2231 net355 VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__mux2_1
Xhold1076 cpuregs\[11\]\[10\] VGND VGND VPWR VPWR net2184 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_58_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1098 cpuregs\[10\]\[19\] VGND VGND VPWR VPWR net2206 sky130_fd_sc_hd__dlygate4sd3_1
X_08748_ _04420_ _04421_ net900 VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__mux2_1
Xhold1087 cpuregs\[10\]\[14\] VGND VGND VPWR VPWR net2195 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_26_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08679_ decoded_imm\[10\] net600 net626 VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__a21o_1
XFILLER_54_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10710_ clknet_leaf_100_clk _00802_ VGND VGND VPWR VPWR mem_do_prefetch sky130_fd_sc_hd__dfxtp_1
XFILLER_53_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10641_ clknet_leaf_82_clk _00765_ VGND VGND VPWR VPWR count_cycle\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_139_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10572_ clknet_leaf_61_clk _00696_ VGND VGND VPWR VPWR reg_next_pc\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11124_ clknet_leaf_148_clk _01165_ VGND VGND VPWR VPWR cpuregs\[31\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11055_ clknet_leaf_102_clk _01106_ VGND VGND VPWR VPWR mem_rdata_q\[12\] sky130_fd_sc_hd__dfxtp_1
X_10006_ clknet_leaf_79_clk _00130_ VGND VGND VPWR VPWR cpuregs\[12\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_77_876 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_2022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_106_2033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10908_ clknet_leaf_8_clk _00964_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dfxtp_1
XFILLER_60_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10839_ clknet_leaf_111_clk _00898_ VGND VGND VPWR VPWR decoded_rd\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_146_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06030_ decoded_imm_j\[2\] _01116_ net330 VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__mux2_1
XFILLER_141_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07981_ _03704_ _03705_ _03786_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__and3_1
X_06932_ _03339_ _03340_ net735 VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__mux2_1
X_09720_ net279 net1986 net363 VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__mux2_1
XFILLER_95_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09651_ net287 net1935 net371 VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__mux2_1
X_06863_ net858 net513 VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__or2_1
XFILLER_95_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05814_ _02073_ net576 net585 VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__a21oi_1
X_06794_ _03209_ _03210_ net651 VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__mux2_1
X_09582_ net1456 net301 net377 VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__mux2_1
XFILLER_55_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08602_ _04293_ _04294_ net482 _04291_ VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__o211a_1
XFILLER_82_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05745_ _02195_ _02197_ net692 VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__a21o_1
X_08533_ net664 _04227_ net659 VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__a21oi_1
X_08464_ net652 _04197_ _04196_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__a21oi_1
X_05676_ net831 _01561_ _02254_ VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_137_2516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07415_ net1525 net279 net440 VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__mux2_1
X_08395_ _04143_ net996 _04142_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__and3b_1
XFILLER_148_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_137_2527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07346_ net1334 net293 net447 VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__mux2_1
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_2738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_2727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09016_ net682 _04685_ VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__or2_1
X_07277_ net1844 net299 net454 VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__mux2_1
XFILLER_151_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06228_ reg_out\[23\] alu_out_q\[23\] net842 VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__mux2_1
XFILLER_132_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06159_ _02613_ _02616_ net565 VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__mux2_2
XFILLER_3_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold162 cpuregs\[15\]\[2\] VGND VGND VPWR VPWR net1270 sky130_fd_sc_hd__dlygate4sd3_1
Xhold151 cpuregs\[2\]\[11\] VGND VGND VPWR VPWR net1259 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 cpuregs\[31\]\[11\] VGND VGND VPWR VPWR net1248 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold173 cpuregs\[29\]\[29\] VGND VGND VPWR VPWR net1281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 cpuregs\[25\]\[24\] VGND VGND VPWR VPWR net1292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 cpuregs\[1\]\[6\] VGND VGND VPWR VPWR net1303 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout642 net643 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__buf_4
XFILLER_104_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout620 net621 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__clkbuf_2
XFILLER_78_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09918_ clknet_leaf_15_clk _00047_ VGND VGND VPWR VPWR cpuregs\[11\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xfanout631 _01573_ VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__clkbuf_4
Xfanout653 net654 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout675 net676 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__buf_2
Xfanout664 net665 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__buf_4
Xfanout686 net687 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__clkbuf_2
X_09849_ net292 net2102 net347 VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__mux2_1
XFILLER_74_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout697 net699 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__clkbuf_2
XFILLER_37_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10624_ clknet_leaf_107_clk _00748_ VGND VGND VPWR VPWR count_cycle\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10555_ clknet_leaf_128_clk _00679_ VGND VGND VPWR VPWR reg_next_pc\[4\] sky130_fd_sc_hd__dfxtp_1
X_10486_ clknet_leaf_89_clk _00610_ VGND VGND VPWR VPWR count_instr\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11107_ clknet_leaf_131_clk _00004_ VGND VGND VPWR VPWR reg_sh\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_9_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11038_ clknet_leaf_87_clk _00032_ VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__dfxtp_1
XFILLER_92_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05530_ net870 net210 VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__and2_1
XFILLER_21_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05461_ count_instr\[31\] net823 net623 _02041_ VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__a211o_1
XFILLER_20_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08180_ _03984_ _03985_ net1002 VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_119_2235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05392_ _01963_ _01967_ _01976_ VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__a21o_1
X_07200_ net2053 net475 net462 VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__mux2_1
X_07131_ _03533_ _03534_ _03535_ _03511_ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__a211o_1
XFILLER_145_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07062_ net736 _03469_ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_132_2446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput201 net201 VGND VGND VPWR VPWR pcpi_rs1[8] sky130_fd_sc_hd__buf_2
Xoutput223 net223 VGND VGND VPWR VPWR pcpi_rs2[28] sky130_fd_sc_hd__buf_2
X_06013_ reg_out\[27\] reg_next_pc\[27\] net575 VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__mux2_1
Xoutput212 net212 VGND VGND VPWR VPWR pcpi_rs2[18] sky130_fd_sc_hd__buf_2
Xoutput234 net234 VGND VGND VPWR VPWR pcpi_rs2[9] sky130_fd_sc_hd__buf_2
XFILLER_101_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07964_ _03702_ _03763_ _03703_ VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__a21o_1
XFILLER_110_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07895_ reg_pc\[29\] net505 _03726_ net605 VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__a22o_1
X_06915_ decoded_imm\[21\] net862 _03303_ VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__a21oi_1
XFILLER_83_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_52_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09703_ net527 net1750 net362 VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__mux2_1
X_06846_ cpuregs\[24\]\[19\] cpuregs\[25\]\[19\] cpuregs\[26\]\[19\] cpuregs\[27\]\[19\]
+ net795 net758 VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__mux4_1
XFILLER_67_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09634_ net535 net1598 net372 VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__mux2_1
XFILLER_83_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09565_ net1710 net238 net382 VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__mux2_1
X_06777_ _03193_ _03194_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__nand2_1
X_09496_ net1217 net250 net392 VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__mux2_1
X_05728_ _02296_ _02297_ _02299_ VGND VGND VPWR VPWR alu_out\[8\] sky130_fd_sc_hd__o21ai_1
X_08516_ net717 _01662_ _04215_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__nor3_1
XFILLER_12_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08447_ cpuregs\[7\]\[31\] net794 net756 VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__a21bo_1
XFILLER_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05659_ is_sltiu_bltu_sltu _02235_ _02236_ instr_bge VGND VGND VPWR VPWR _02239_
+ sky130_fd_sc_hd__a22oi_1
X_08378_ net2288 _04130_ _04132_ VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__a21oi_1
XFILLER_149_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07329_ net1390 net539 net446 VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__mux2_1
XFILLER_124_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10340_ clknet_leaf_4_clk _00464_ VGND VGND VPWR VPWR cpuregs\[16\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10271_ clknet_leaf_151_clk _00395_ VGND VGND VPWR VPWR cpuregs\[15\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout450 net453 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__clkbuf_8
Xfanout461 _03568_ VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout483 net486 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__buf_4
Xfanout472 _02604_ VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__clkbuf_2
XFILLER_74_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout494 _02596_ VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__buf_2
XFILLER_19_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10607_ clknet_leaf_88_clk _00731_ VGND VGND VPWR VPWR count_cycle\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_115_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold909 cpuregs\[3\]\[19\] VGND VGND VPWR VPWR net2017 sky130_fd_sc_hd__dlygate4sd3_1
X_10538_ clknet_leaf_59_clk _00662_ VGND VGND VPWR VPWR reg_pc\[18\] sky130_fd_sc_hd__dfxtp_2
XFILLER_6_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10469_ clknet_leaf_105_clk _00593_ VGND VGND VPWR VPWR count_instr\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04961_ _01579_ _01580_ _01581_ _01587_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__or4_1
XFILLER_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06700_ net875 net510 net489 _03120_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__o211a_1
X_07680_ _03597_ net980 _03596_ VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__and3b_1
XFILLER_80_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06631_ cpuregs\[4\]\[11\] cpuregs\[5\]\[11\] cpuregs\[6\]\[11\] cpuregs\[7\]\[11\]
+ net778 net742 VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__mux4_1
X_09350_ mem_rdata_q\[23\] net616 VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__and2_1
XFILLER_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06562_ _02985_ _02987_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__nand2_1
X_05513_ net857 net220 VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__nor2_1
X_08301_ _04084_ net987 _04083_ VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__and3b_1
X_09281_ net1168 net125 net483 VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__mux2_1
X_08232_ _04014_ _04015_ _04023_ _04032_ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__a31o_1
XFILLER_60_381 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_153_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_153_clk sky130_fd_sc_hd__clkbuf_8
X_06493_ cpuregs\[8\]\[6\] cpuregs\[9\]\[6\] cpuregs\[10\]\[6\] cpuregs\[11\]\[6\]
+ net775 net739 VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__mux4_1
X_05444_ _02012_ _02015_ VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__and2b_1
X_08163_ net837 _03968_ _03969_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__and3_1
X_05375_ reg_pc\[25\] decoded_imm\[25\] VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__or2_1
X_07114_ cpuregs\[12\]\[29\] cpuregs\[13\]\[29\] cpuregs\[14\]\[29\] cpuregs\[15\]\[29\]
+ net805 net768 VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__mux4_1
XFILLER_118_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08094_ net689 reg_next_pc\[17\] net546 _03713_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__a22o_1
XFILLER_146_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload60 clknet_leaf_35_clk VGND VGND VPWR VPWR clkload60/X sky130_fd_sc_hd__clkbuf_8
Xclkload71 clknet_leaf_56_clk VGND VGND VPWR VPWR clkload71/Y sky130_fd_sc_hd__inv_6
X_07045_ decoded_imm\[27\] net855 VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__nand2_1
Xclkload82 clknet_leaf_51_clk VGND VGND VPWR VPWR clkload82/Y sky130_fd_sc_hd__clkinv_2
Xclkload93 clknet_leaf_99_clk VGND VGND VPWR VPWR clkload93/Y sky130_fd_sc_hd__clkinv_8
XTAP_TAPCELL_ROW_54_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08996_ net904 _04666_ VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__or2_1
XFILLER_102_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07947_ _03768_ _03770_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_145_2659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07878_ _02662_ reg_next_pc\[21\] net573 VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__mux2_2
XFILLER_55_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09617_ net292 net2118 net375 VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__mux2_1
X_06829_ decoded_imm\[19\] net865 VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__or2_1
XFILLER_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09548_ net1522 net309 net382 VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__mux2_1
XFILLER_70_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_65_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09479_ net1709 net322 net389 VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_144_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_144_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_133_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11441_ clknet_leaf_121_clk _01479_ VGND VGND VPWR VPWR cpuregs\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_902 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11372_ clknet_leaf_70_clk _01410_ VGND VGND VPWR VPWR cpuregs\[6\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10323_ clknet_leaf_66_clk _00447_ VGND VGND VPWR VPWR cpuregs\[26\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_10254_ clknet_leaf_42_clk _00378_ VGND VGND VPWR VPWR cpuregs\[27\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10185_ clknet_leaf_31_clk _00309_ VGND VGND VPWR VPWR cpuregs\[9\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout280 net282 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout291 _02650_ VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_2
XFILLER_47_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_135_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_135_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_15_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05160_ count_instr\[40\] net815 net824 count_cycle\[40\] VGND VGND VPWR VPWR _01764_
+ sky130_fd_sc_hd__a22o_1
Xhold717 cpuregs\[6\]\[25\] VGND VGND VPWR VPWR net1825 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_128_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold706 cpuregs\[4\]\[30\] VGND VGND VPWR VPWR net1814 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold728 cpuregs\[5\]\[11\] VGND VGND VPWR VPWR net1836 sky130_fd_sc_hd__dlygate4sd3_1
Xhold739 cpuregs\[8\]\[16\] VGND VGND VPWR VPWR net1847 sky130_fd_sc_hd__dlygate4sd3_1
X_05091_ net706 net882 _01696_ net702 _01699_ VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__a221o_1
XFILLER_124_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08850_ cpuregs\[12\]\[20\] cpuregs\[13\]\[20\] cpuregs\[14\]\[20\] cpuregs\[15\]\[20\]
+ net963 net928 VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__mux4_1
XFILLER_69_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07801_ count_instr\[51\] _03672_ net995 VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_127_2356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08781_ cpuregs\[0\]\[16\] cpuregs\[1\]\[16\] cpuregs\[2\]\[16\] cpuregs\[3\]\[16\]
+ net965 net930 VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__mux4_1
X_05993_ reg_out\[17\] reg_next_pc\[17\] net572 VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__mux2_1
XFILLER_69_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_127_2367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07732_ net2343 _03628_ net997 VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__o21ai_1
XFILLER_93_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04944_ net850 net979 _01571_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__and3_1
XFILLER_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07663_ count_instr\[0\] net559 net979 VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_140_2567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06614_ net304 _03020_ _03038_ _03010_ VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__a31o_1
XFILLER_26_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09402_ net539 net2013 net397 VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_140_2578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09333_ net836 net813 _04827_ VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__a21o_1
X_07594_ latched_rd\[3\] latched_rd\[4\] _02579_ latched_rd\[2\] VGND VGND VPWR VPWR
+ _03582_ sky130_fd_sc_hd__and4b_1
XFILLER_40_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_126_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_126_clk sky130_fd_sc_hd__clkbuf_8
X_06545_ cpuregs\[24\]\[8\] cpuregs\[25\]\[8\] cpuregs\[26\]\[8\] cpuregs\[27\]\[8\]
+ net774 net738 VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__mux4_1
XFILLER_34_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09264_ mem_do_wdata net851 net634 _01572_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_16_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06476_ reg_pc\[5\] net560 _02905_ net520 VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__a211o_1
X_08215_ _04014_ _04016_ net838 VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__o21a_1
X_05427_ net703 net343 _02006_ _02010_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__a31o_1
X_09195_ net2358 _01124_ net333 VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__mux2_1
XFILLER_21_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08146_ net812 _03718_ _03949_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_60_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05358_ net714 _01940_ _01946_ VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__a21o_1
XFILLER_106_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05289_ _01871_ _01874_ _01881_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__a21oi_1
X_08077_ net559 _03889_ _03890_ VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__a21o_1
X_07028_ net608 _03432_ _03433_ _03436_ VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__a31o_1
XFILLER_115_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold11 cpuregs\[0\]\[22\] VGND VGND VPWR VPWR net1119 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_88_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold22 cpuregs\[0\]\[8\] VGND VGND VPWR VPWR net1130 sky130_fd_sc_hd__dlygate4sd3_1
X_08979_ cpuregs\[12\]\[27\] cpuregs\[13\]\[27\] cpuregs\[14\]\[27\] cpuregs\[15\]\[27\]
+ net970 net935 VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__mux4_1
Xhold44 net147 VGND VGND VPWR VPWR net1152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 net143 VGND VGND VPWR VPWR net1163 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold33 cpuregs\[0\]\[11\] VGND VGND VPWR VPWR net1141 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 net40 VGND VGND VPWR VPWR net1196 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 net49 VGND VGND VPWR VPWR net1207 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_91_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold66 net140 VGND VGND VPWR VPWR net1174 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 net146 VGND VGND VPWR VPWR net1185 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_67_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10941_ clknet_leaf_131_clk _00997_ VGND VGND VPWR VPWR reg_sh\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10872_ clknet_leaf_12_clk _00928_ VGND VGND VPWR VPWR cpuregs\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_80_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_117_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_117_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_14_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11424_ clknet_leaf_54_clk _01462_ VGND VGND VPWR VPWR cpuregs\[8\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_8 _01640_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_2113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_808 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11355_ clknet_leaf_5_clk _01393_ VGND VGND VPWR VPWR cpuregs\[6\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10306_ clknet_leaf_14_clk _00430_ VGND VGND VPWR VPWR cpuregs\[26\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_11286_ clknet_leaf_0_clk _01327_ VGND VGND VPWR VPWR cpuregs\[4\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10237_ clknet_leaf_140_clk _00361_ VGND VGND VPWR VPWR cpuregs\[27\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_91_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10168_ clknet_leaf_138_clk _00292_ VGND VGND VPWR VPWR cpuregs\[9\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_10099_ clknet_leaf_69_clk _00223_ VGND VGND VPWR VPWR cpuregs\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_708 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_2075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_122_2286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_108_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_108_clk sky130_fd_sc_hd__clkbuf_8
X_06330_ net752 _02762_ _02763_ _02761_ net650 VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__o221a_1
XFILLER_31_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06261_ _02697_ _02698_ VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__nor2_1
XFILLER_129_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05212_ _01760_ _01811_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__or2_1
X_08000_ _03814_ _03819_ net832 VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__mux2_1
X_06192_ reg_out\[16\] alu_out_q\[16\] net842 VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__mux2_1
XFILLER_144_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold514 cpuregs\[9\]\[23\] VGND VGND VPWR VPWR net1622 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold525 cpuregs\[24\]\[21\] VGND VGND VPWR VPWR net1633 sky130_fd_sc_hd__dlygate4sd3_1
Xhold536 cpuregs\[4\]\[17\] VGND VGND VPWR VPWR net1644 sky130_fd_sc_hd__dlygate4sd3_1
X_05143_ net884 net7 _01747_ net171 net698 VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__o2111a_1
Xhold503 cpuregs\[13\]\[0\] VGND VGND VPWR VPWR net1611 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold569 cpuregs\[31\]\[21\] VGND VGND VPWR VPWR net1677 sky130_fd_sc_hd__dlygate4sd3_1
Xhold558 cpuregs\[12\]\[13\] VGND VGND VPWR VPWR net1666 sky130_fd_sc_hd__dlygate4sd3_1
Xhold547 cpuregs\[11\]\[6\] VGND VGND VPWR VPWR net1655 sky130_fd_sc_hd__dlygate4sd3_1
X_09951_ clknet_leaf_141_clk _00075_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dfxtp_1
X_05074_ _01683_ net713 _01682_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__and3b_1
X_08902_ cpuregs\[4\]\[23\] cpuregs\[5\]\[23\] cpuregs\[6\]\[23\] cpuregs\[7\]\[23\]
+ net966 net931 VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__mux4_1
XFILLER_131_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09882_ net1113 VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__clkbuf_1
XFILLER_112_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08833_ cpuregs\[0\]\[19\] cpuregs\[1\]\[19\] cpuregs\[2\]\[19\] cpuregs\[3\]\[19\]
+ net961 net926 VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__mux4_1
Xhold1225 count_cycle\[50\] VGND VGND VPWR VPWR net2333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1203 instr_srl VGND VGND VPWR VPWR net2311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1214 reg_sh\[4\] VGND VGND VPWR VPWR net2322 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_142_2607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1247 count_cycle\[25\] VGND VGND VPWR VPWR net2355 sky130_fd_sc_hd__dlygate4sd3_1
X_08764_ net900 _04440_ net893 VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__o21a_1
Xhold1236 instr_xor VGND VGND VPWR VPWR net2344 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1258 is_beq_bne_blt_bge_bltu_bgeu VGND VGND VPWR VPWR net2366 sky130_fd_sc_hd__dlygate4sd3_1
X_05976_ net201 _02490_ net634 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__mux2_1
Xhold1269 reg_pc\[23\] VGND VGND VPWR VPWR net2377 sky130_fd_sc_hd__dlygate4sd3_1
X_07715_ _03618_ _03619_ VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_49_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04927_ net889 VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__inv_2
XFILLER_93_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08695_ decoded_imm\[11\] net600 net626 VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_49_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_146_Right_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07646_ net292 net1834 net412 VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__mux2_1
XFILLER_81_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07577_ net1521 net301 net419 VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06528_ reg_pc\[7\] net560 _02955_ net516 net520 VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__a221o_1
X_09316_ _01630_ _04817_ VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__or2_2
X_09247_ net1958 net279 net404 VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06459_ cpuregs\[20\]\[5\] cpuregs\[21\]\[5\] cpuregs\[22\]\[5\] cpuregs\[23\]\[5\]
+ net776 net740 VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__mux4_1
XFILLER_147_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09178_ _04780_ _04790_ net823 net549 VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__a2bb2o_1
X_08129_ net557 _03938_ VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__nor2_1
XFILLER_135_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_134_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11140_ clknet_leaf_45_clk _01181_ VGND VGND VPWR VPWR cpuregs\[31\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_150_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput56 net56 VGND VGND VPWR VPWR mem_addr[30] sky130_fd_sc_hd__buf_2
Xoutput45 net45 VGND VGND VPWR VPWR mem_addr[20] sky130_fd_sc_hd__buf_2
Xoutput67 net67 VGND VGND VPWR VPWR mem_la_addr[11] sky130_fd_sc_hd__buf_2
Xoutput78 net78 VGND VGND VPWR VPWR mem_la_addr[22] sky130_fd_sc_hd__buf_2
X_11071_ clknet_leaf_92_clk _01122_ VGND VGND VPWR VPWR mem_rdata_q\[28\] sky130_fd_sc_hd__dfxtp_1
Xoutput89 net89 VGND VGND VPWR VPWR mem_la_addr[3] sky130_fd_sc_hd__buf_2
X_10022_ clknet_leaf_26_clk _00146_ VGND VGND VPWR VPWR cpuregs\[30\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10924_ clknet_leaf_38_clk _00980_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10855_ clknet_leaf_98_clk net1215 VGND VGND VPWR VPWR is_slli_srli_srai sky130_fd_sc_hd__dfxtp_1
XFILLER_44_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10786_ clknet_leaf_103_clk _00845_ VGND VGND VPWR VPWR instr_auipc sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11407_ clknet_leaf_24_clk _01445_ VGND VGND VPWR VPWR cpuregs\[7\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_93_1816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11338_ clknet_leaf_76_clk _01379_ VGND VGND VPWR VPWR cpuregs\[5\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_93_1827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11269_ clknet_leaf_56_clk _01310_ VGND VGND VPWR VPWR cpuregs\[22\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05830_ _02061_ net585 VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__and2b_1
XFILLER_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_124_2315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05761_ _02158_ net583 VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__and2b_1
X_07500_ net1858 net475 net426 VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05692_ _02168_ _02263_ _02268_ VGND VGND VPWR VPWR alu_out\[3\] sky130_fd_sc_hd__a21o_1
X_08480_ net94 net1206 net406 VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__mux2_1
XFILLER_35_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07431_ net1349 net532 net435 VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_102_1956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07362_ net538 net1869 net442 VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09101_ net719 _04751_ VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__nor2_1
XFILLER_31_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06313_ net888 _02747_ net304 VGND VGND VPWR VPWR _00069_ sky130_fd_sc_hd__mux2_1
X_07293_ net1789 net236 net456 VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__mux2_1
XFILLER_30_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09032_ net904 _04700_ VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__or2_1
X_06244_ reg_out\[26\] alu_out_q\[26\] net843 VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_135_2499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold300 cpuregs\[21\]\[25\] VGND VGND VPWR VPWR net1408 sky130_fd_sc_hd__dlygate4sd3_1
X_06175_ net318 net2145 net476 VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__mux2_1
Xhold311 cpuregs\[15\]\[0\] VGND VGND VPWR VPWR net1419 sky130_fd_sc_hd__dlygate4sd3_1
Xhold322 cpuregs\[13\]\[21\] VGND VGND VPWR VPWR net1430 sky130_fd_sc_hd__dlygate4sd3_1
Xhold344 cpuregs\[13\]\[24\] VGND VGND VPWR VPWR net1452 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold333 cpuregs\[2\]\[5\] VGND VGND VPWR VPWR net1441 sky130_fd_sc_hd__dlygate4sd3_1
X_05126_ _01727_ _01729_ _01730_ _01723_ VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__a22o_1
Xhold377 cpuregs\[14\]\[29\] VGND VGND VPWR VPWR net1485 sky130_fd_sc_hd__dlygate4sd3_1
Xhold355 cpuregs\[15\]\[14\] VGND VGND VPWR VPWR net1463 sky130_fd_sc_hd__dlygate4sd3_1
Xhold366 cpuregs\[27\]\[14\] VGND VGND VPWR VPWR net1474 sky130_fd_sc_hd__dlygate4sd3_1
X_09934_ clknet_leaf_49_clk _00063_ VGND VGND VPWR VPWR cpuregs\[11\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold388 cpuregs\[26\]\[21\] VGND VGND VPWR VPWR net1496 sky130_fd_sc_hd__dlygate4sd3_1
Xhold399 cpuregs\[15\]\[31\] VGND VGND VPWR VPWR net1507 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout813 net814 VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__clkbuf_4
Xfanout802 net809 VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__buf_2
X_05057_ net887 net698 _01667_ VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__and3_1
Xfanout824 net827 VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__buf_2
Xfanout857 net188 VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__buf_2
XFILLER_86_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1000 cpuregs\[5\]\[14\] VGND VGND VPWR VPWR net2108 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout835 net839 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__clkbuf_4
X_09865_ net985 net134 _04806_ _04880_ _04206_ VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__a41o_1
Xfanout846 net119 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__buf_4
XFILLER_140_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08816_ cpuregs\[4\]\[18\] cpuregs\[5\]\[18\] cpuregs\[6\]\[18\] cpuregs\[7\]\[18\]
+ net959 net924 VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__mux4_1
Xhold1033 cpuregs\[17\]\[19\] VGND VGND VPWR VPWR net2141 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout868 net869 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__buf_2
Xhold1011 cpuregs\[7\]\[4\] VGND VGND VPWR VPWR net2119 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1022 cpuregs\[5\]\[9\] VGND VGND VPWR VPWR net2130 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout879 net199 VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__clkbuf_4
XFILLER_133_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09796_ net240 net1850 net356 VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__mux2_1
Xhold1055 cpuregs\[16\]\[21\] VGND VGND VPWR VPWR net2163 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_85_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1066 cpuregs\[8\]\[0\] VGND VGND VPWR VPWR net2174 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1044 cpuregs\[22\]\[0\] VGND VGND VPWR VPWR net2152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1099 cpuregs\[22\]\[22\] VGND VGND VPWR VPWR net2207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1088 cpuregs\[3\]\[24\] VGND VGND VPWR VPWR net2196 sky130_fd_sc_hd__dlygate4sd3_1
X_05959_ net224 net595 _02480_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__a21o_1
X_08747_ _04425_ _04430_ _04431_ net893 net897 VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__a221o_1
XFILLER_73_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1077 cpuregs\[22\]\[3\] VGND VGND VPWR VPWR net2185 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_39_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08678_ _04365_ _04366_ net482 _04363_ VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__o211a_1
X_07629_ net539 net1978 net410 VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__mux2_1
X_10640_ clknet_leaf_82_clk _00764_ VGND VGND VPWR VPWR count_cycle\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10571_ clknet_leaf_60_clk _00695_ VGND VGND VPWR VPWR reg_next_pc\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_125_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_75_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_800 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11123_ clknet_leaf_145_clk _01164_ VGND VGND VPWR VPWR cpuregs\[31\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11054_ clknet_leaf_111_clk _01105_ VGND VGND VPWR VPWR mem_rdata_q\[11\] sky130_fd_sc_hd__dfxtp_1
X_10005_ clknet_leaf_76_clk _00129_ VGND VGND VPWR VPWR cpuregs\[12\]\[29\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_134_Left_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_2034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10907_ clknet_leaf_6_clk _00963_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dfxtp_1
XFILLER_17_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10838_ clknet_leaf_88_clk _00897_ VGND VGND VPWR VPWR decoded_imm_j\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_20_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10769_ clknet_leaf_59_clk alu_out\[16\] VGND VGND VPWR VPWR alu_out_q\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_146_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_143_Left_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_117_2196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07980_ _03705_ _03791_ VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__nor2_1
X_06931_ _03341_ _03342_ net653 VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__mux2_1
XFILLER_141_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09650_ net291 net2164 net370 VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__mux2_1
X_06862_ _03272_ _03275_ VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__nand2_1
X_08601_ net889 _04292_ net664 VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__a21o_1
X_05813_ _02076_ _02374_ VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__xnor2_1
XFILLER_95_696 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06793_ _03205_ _03206_ net651 VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__mux2_1
X_09581_ net1804 net311 net378 VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__mux2_1
XFILLER_27_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05744_ _02122_ net579 _02311_ _02313_ VGND VGND VPWR VPWR alu_out\[10\] sky130_fd_sc_hd__a211o_1
X_08532_ net895 _04230_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__nand2_1
X_08463_ cpuregs\[16\]\[31\] cpuregs\[17\]\[31\] cpuregs\[18\]\[31\] cpuregs\[19\]\[31\]
+ net794 net759 VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__mux4_1
XFILLER_51_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07414_ net1784 net283 net440 VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__mux2_1
X_05675_ _02184_ _02253_ VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_137_2517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08394_ count_cycle\[49\] _04140_ VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__and2_1
XFILLER_51_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_137_2528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07345_ net1272 net295 net447 VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__mux2_1
XFILLER_109_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_30_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_8
X_07276_ net1703 net308 net456 VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_21_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09015_ cpuregs\[12\]\[29\] cpuregs\[13\]\[29\] cpuregs\[14\]\[29\] cpuregs\[15\]\[29\]
+ net973 net938 VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_150_2728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06227_ net274 net1842 net478 VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_150_2739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_702 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold130 cpuregs\[5\]\[29\] VGND VGND VPWR VPWR net1238 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold152 instr_srai VGND VGND VPWR VPWR net1260 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06158_ _02614_ _02615_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__nor2_1
Xhold141 mem_rdata_q\[9\] VGND VGND VPWR VPWR net1249 sky130_fd_sc_hd__dlygate4sd3_1
Xhold174 cpuregs\[1\]\[25\] VGND VGND VPWR VPWR net1282 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05109_ net887 net698 _01715_ VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__and3_1
Xhold185 cpuregs\[21\]\[9\] VGND VGND VPWR VPWR net1293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold163 cpuregs\[14\]\[11\] VGND VGND VPWR VPWR net1271 sky130_fd_sc_hd__dlygate4sd3_1
X_06089_ net811 decoded_imm_j\[3\] net705 VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__a21o_1
Xfanout610 _01612_ VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__buf_2
Xfanout621 _01576_ VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__buf_2
Xfanout632 net633 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__clkbuf_4
Xhold196 cpuregs\[30\]\[6\] VGND VGND VPWR VPWR net1304 sky130_fd_sc_hd__dlygate4sd3_1
X_09917_ clknet_leaf_2_clk _00046_ VGND VGND VPWR VPWR cpuregs\[11\]\[9\] sky130_fd_sc_hd__dfxtp_1
Xfanout654 net657 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__buf_4
Xclkbuf_leaf_97_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_97_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_70_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_855 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout643 _01568_ VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__clkbuf_8
Xfanout676 _01555_ VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__clkbuf_4
Xfanout665 net668 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__clkbuf_8
X_09848_ net295 net1930 net347 VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__mux2_1
Xfanout687 _01552_ VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__buf_4
XFILLER_86_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout698 net699 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09779_ net312 net1698 net353 VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__mux2_1
XFILLER_46_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_1_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10623_ clknet_leaf_107_clk _00747_ VGND VGND VPWR VPWR count_cycle\[40\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_21_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
X_10554_ clknet_leaf_128_clk _00678_ VGND VGND VPWR VPWR reg_next_pc\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_40_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10485_ clknet_leaf_81_clk _00609_ VGND VGND VPWR VPWR count_instr\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11106_ clknet_leaf_56_clk _01157_ VGND VGND VPWR VPWR cpuregs\[24\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_88_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_88_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_77_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11037_ clknet_leaf_24_clk _01093_ VGND VGND VPWR VPWR cpuregs\[19\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_77_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_774 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_151_Left_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05460_ count_instr\[63\] net816 net825 count_cycle\[63\] VGND VGND VPWR VPWR _02041_
+ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_119_2236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05391_ _01963_ _01967_ _01976_ VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__nand3_1
XFILLER_60_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07130_ _03487_ _03490_ _03510_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_leaf_12_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_9_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_145_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07061_ cpuregs\[0\]\[27\] cpuregs\[1\]\[27\] cpuregs\[2\]\[27\] cpuregs\[3\]\[27\]
+ net803 net766 VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_132_2447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_2436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput213 net213 VGND VGND VPWR VPWR pcpi_rs2[19] sky130_fd_sc_hd__buf_2
Xoutput224 net224 VGND VGND VPWR VPWR pcpi_rs2[29] sky130_fd_sc_hd__buf_2
X_06012_ net189 _02508_ net637 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__mux2_1
Xoutput202 net202 VGND VGND VPWR VPWR pcpi_rs1[9] sky130_fd_sc_hd__buf_2
Xoutput235 net235 VGND VGND VPWR VPWR trap sky130_fd_sc_hd__buf_2
XFILLER_114_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_79_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_79_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07963_ _03702_ _03703_ _03763_ VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__and3_1
X_07894_ _02696_ reg_next_pc\[29\] net575 VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__mux2_2
X_06914_ _03325_ _03326_ VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_52_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09702_ net530 net1828 net362 VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_147_2690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_782 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06845_ cpuregs\[28\]\[19\] cpuregs\[29\]\[19\] cpuregs\[30\]\[19\] cpuregs\[31\]\[19\]
+ net795 net758 VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__mux4_1
XFILLER_68_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09633_ net539 net2152 net369 VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__mux2_1
X_09564_ net1429 net242 net383 VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__mux2_1
XFILLER_56_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06776_ decoded_imm\[17\] net868 VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__or2_1
X_08515_ net850 cpu_state\[1\] cpu_state\[0\] net979 VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__or4b_1
XFILLER_43_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09495_ net1889 net251 net392 VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__mux2_1
X_05727_ _02135_ net578 _02298_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__o21a_1
X_08446_ net794 cpuregs\[6\]\[31\] VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__and2b_1
X_05658_ _01545_ _02176_ _02235_ _01544_ _02046_ VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__o221a_1
XFILLER_24_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08377_ count_cycle\[43\] _04130_ net988 VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__o21ai_1
XFILLER_149_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05589_ _02167_ _02168_ VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__nand2_1
X_07328_ _03567_ _03571_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__nor2_1
XFILLER_139_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07259_ net1232 net241 net461 VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__mux2_1
XFILLER_118_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10270_ clknet_leaf_143_clk _00394_ VGND VGND VPWR VPWR cpuregs\[15\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout440 _03574_ VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_6_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout484 net486 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__clkbuf_4
Xfanout451 net452 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_4
Xfanout473 net474 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__clkbuf_2
Xfanout462 net465 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__clkbuf_8
XFILLER_86_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout495 _01627_ VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__buf_2
XFILLER_100_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10606_ clknet_leaf_88_clk _00730_ VGND VGND VPWR VPWR count_cycle\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_116_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10537_ clknet_leaf_59_clk _00661_ VGND VGND VPWR VPWR reg_pc\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_127_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_2155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10468_ clknet_leaf_105_clk _00592_ VGND VGND VPWR VPWR count_instr\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10399_ clknet_leaf_152_clk _00523_ VGND VGND VPWR VPWR cpuregs\[20\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04960_ instr_beq instr_rdcycle instr_srai instr_slli VGND VGND VPWR VPWR _01587_
+ sky130_fd_sc_hd__or4_1
Xclkbuf_leaf_1_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_37_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_806 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06630_ cpuregs\[20\]\[11\] cpuregs\[21\]\[11\] cpuregs\[22\]\[11\] cpuregs\[23\]\[11\]
+ net773 net737 VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__mux4_1
XFILLER_37_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06561_ decoded_imm\[9\] net876 VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__or2_1
X_05512_ _02089_ _02091_ VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__nand2_1
X_08300_ count_cycle\[13\] count_cycle\[14\] _04080_ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__and3_1
X_09280_ net1139 net845 net483 VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__mux2_1
X_06492_ cpuregs\[12\]\[6\] cpuregs\[13\]\[6\] cpuregs\[14\]\[6\] cpuregs\[15\]\[6\]
+ net775 net739 VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__mux4_1
X_08231_ _03722_ _03723_ _03724_ _03725_ net813 VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__o41a_1
X_05443_ reg_pc\[30\] decoded_imm\[30\] VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__or2_1
XFILLER_61_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08162_ _03949_ _03967_ _03966_ _03956_ VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__o211ai_2
X_05374_ net714 _01954_ _01955_ _01961_ VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__a31o_1
XFILLER_146_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07113_ cpuregs\[28\]\[29\] cpuregs\[29\]\[29\] cpuregs\[30\]\[29\] cpuregs\[31\]\[29\]
+ net807 net770 VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__mux4_1
X_08093_ _03905_ _03903_ _03893_ _03892_ VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__a2bb2o_1
Xclkload61 clknet_leaf_37_clk VGND VGND VPWR VPWR clkload61/Y sky130_fd_sc_hd__inv_8
XFILLER_106_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07044_ decoded_imm\[27\] net855 VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__nor2_1
Xclkload50 clknet_leaf_25_clk VGND VGND VPWR VPWR clkload50/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload83 clknet_leaf_53_clk VGND VGND VPWR VPWR clkload83/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_115_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload72 clknet_leaf_57_clk VGND VGND VPWR VPWR clkload72/Y sky130_fd_sc_hd__inv_6
XTAP_TAPCELL_ROW_54_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload94 clknet_leaf_127_clk VGND VGND VPWR VPWR clkload94/Y sky130_fd_sc_hd__inv_8
X_08995_ cpuregs\[24\]\[28\] cpuregs\[25\]\[28\] cpuregs\[26\]\[28\] cpuregs\[27\]\[28\]
+ net973 net938 VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__mux4_1
XFILLER_114_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07946_ _03769_ VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_145_2649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_96_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07877_ net2373 net504 _03717_ net605 VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__a22o_1
XFILLER_141_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09616_ net295 net1826 net376 VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__mux2_1
X_06828_ decoded_imm\[19\] net865 VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__nor2_1
XFILLER_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06759_ cpuregs\[4\]\[16\] cpuregs\[5\]\[16\] cpuregs\[6\]\[16\] cpuregs\[7\]\[16\]
+ net794 net759 VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__mux4_1
X_09547_ net1504 net313 net381 VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09478_ net1741 _02620_ net389 VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__mux2_1
XFILLER_51_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08429_ count_cycle\[61\] count_cycle\[62\] _04161_ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__and3_1
XFILLER_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload0 clknet_4_0_0_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__inv_8
X_11440_ clknet_leaf_138_clk _01478_ VGND VGND VPWR VPWR cpuregs\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_11371_ clknet_leaf_70_clk _01409_ VGND VGND VPWR VPWR cpuregs\[6\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_10322_ clknet_leaf_48_clk _00446_ VGND VGND VPWR VPWR cpuregs\[26\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_830 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10253_ clknet_leaf_43_clk _00377_ VGND VGND VPWR VPWR cpuregs\[27\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10184_ clknet_leaf_52_clk _00308_ VGND VGND VPWR VPWR cpuregs\[9\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout270 _02674_ VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout281 net282 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__clkbuf_2
Xfanout292 _02650_ VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_1
XFILLER_59_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_147_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold718 cpuregs\[3\]\[16\] VGND VGND VPWR VPWR net1826 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold707 cpuregs\[18\]\[1\] VGND VGND VPWR VPWR net1815 sky130_fd_sc_hd__dlygate4sd3_1
Xhold729 cpuregs\[3\]\[25\] VGND VGND VPWR VPWR net1837 sky130_fd_sc_hd__dlygate4sd3_1
X_05090_ count_cycle\[3\] net617 net589 _01698_ VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__o211a_1
XFILLER_131_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_124_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08780_ cpuregs\[4\]\[16\] cpuregs\[5\]\[16\] cpuregs\[6\]\[16\] cpuregs\[7\]\[16\]
+ net962 net927 VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__mux4_1
XFILLER_111_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07800_ _03672_ _03673_ VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07731_ count_instr\[25\] count_instr\[24\] _03626_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__and3_1
X_05992_ net178 _02498_ net636 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__mux2_2
XFILLER_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_2368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04943_ net851 net635 _01571_ net979 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__o211a_1
X_07662_ net718 net848 VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__nand2_1
X_07593_ net1457 _02708_ net421 VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__mux2_1
X_06613_ reg_pc\[10\] net560 _03037_ net516 net520 VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__a221o_1
XFILLER_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09401_ _03565_ _03579_ VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_140_2579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09332_ mem_rdata_q\[31\] _04826_ net550 VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__a21o_2
X_06544_ cpuregs\[28\]\[8\] cpuregs\[29\]\[8\] cpuregs\[30\]\[8\] cpuregs\[31\]\[8\]
+ net776 net740 VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__mux4_1
XFILLER_34_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09263_ _04803_ net1414 net407 VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__mux2_1
X_06475_ _02904_ _02895_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__and2b_1
X_08214_ _04014_ _04016_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__nand2_1
X_05426_ net590 _02008_ _02009_ net854 net708 VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__a32o_1
X_09194_ mem_rdata_q\[30\] net24 net613 VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__mux2_1
X_08145_ _03952_ _03953_ net991 VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__o21a_1
X_05357_ net703 net343 _01941_ _01945_ VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_60_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05288_ _01871_ _01874_ _01881_ VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__and3_1
X_08076_ net689 reg_next_pc\[16\] net546 _03712_ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__a22o_1
XFILLER_20_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07027_ net490 _03359_ _03434_ _03435_ net525 VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__a311o_1
XFILLER_1_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold23 cpuregs\[0\]\[23\] VGND VGND VPWR VPWR net1131 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_76_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold12 instr_auipc VGND VGND VPWR VPWR net1120 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_48_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08978_ net904 _04649_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__or2_1
Xhold34 cpuregs\[0\]\[24\] VGND VGND VPWR VPWR net1142 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold56 net155 VGND VGND VPWR VPWR net1164 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_69_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold45 net161 VGND VGND VPWR VPWR net1153 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 instr_addi VGND VGND VPWR VPWR net1175 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 instr_add VGND VGND VPWR VPWR net1186 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_56_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold89 net62 VGND VGND VPWR VPWR net1197 sky130_fd_sc_hd__dlygate4sd3_1
X_07929_ net688 reg_next_pc\[4\] net545 _03700_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__a22o_1
XFILLER_84_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10940_ clknet_leaf_112_clk _00996_ VGND VGND VPWR VPWR latched_rd\[4\] sky130_fd_sc_hd__dfxtp_2
XFILLER_71_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10871_ clknet_leaf_0_clk _00927_ VGND VGND VPWR VPWR cpuregs\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_80_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11423_ clknet_leaf_21_clk _01461_ VGND VGND VPWR VPWR cpuregs\[8\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_9 _01678_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_2103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11354_ clknet_leaf_13_clk _01392_ VGND VGND VPWR VPWR cpuregs\[6\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_721 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10305_ clknet_leaf_151_clk _00429_ VGND VGND VPWR VPWR cpuregs\[26\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_11285_ clknet_leaf_3_clk _01326_ VGND VGND VPWR VPWR cpuregs\[4\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10236_ clknet_leaf_128_clk _00360_ VGND VGND VPWR VPWR cpuregs\[27\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_91_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10167_ clknet_leaf_23_clk _00291_ VGND VGND VPWR VPWR cpuregs\[21\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10098_ clknet_leaf_47_clk _00222_ VGND VGND VPWR VPWR cpuregs\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_109_2076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_122_2276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_168 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06260_ reg_pc\[29\] reg_pc\[28\] _02690_ VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__and3_1
XFILLER_89_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05211_ net4 _01653_ _01654_ net21 _01761_ VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__o221a_1
XFILLER_129_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06191_ net300 net2041 net477 VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__mux2_1
XFILLER_144_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold504 cpuregs\[29\]\[27\] VGND VGND VPWR VPWR net1612 sky130_fd_sc_hd__dlygate4sd3_1
X_05142_ net25 net884 VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__nand2b_1
Xhold526 cpuregs\[3\]\[12\] VGND VGND VPWR VPWR net1634 sky130_fd_sc_hd__dlygate4sd3_1
Xhold515 cpuregs\[26\]\[10\] VGND VGND VPWR VPWR net1623 sky130_fd_sc_hd__dlygate4sd3_1
Xhold537 cpuregs\[21\]\[22\] VGND VGND VPWR VPWR net1645 sky130_fd_sc_hd__dlygate4sd3_1
Xhold559 cpuregs\[21\]\[31\] VGND VGND VPWR VPWR net1667 sky130_fd_sc_hd__dlygate4sd3_1
Xhold548 cpuregs\[5\]\[15\] VGND VGND VPWR VPWR net1656 sky130_fd_sc_hd__dlygate4sd3_1
X_09950_ clknet_leaf_136_clk _00074_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dfxtp_1
X_05073_ _01673_ _01679_ _01681_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__and3b_1
XFILLER_143_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08901_ cpuregs\[24\]\[23\] cpuregs\[25\]\[23\] cpuregs\[26\]\[23\] cpuregs\[27\]\[23\]
+ net966 net931 VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__mux4_1
XFILLER_131_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09881_ net1127 VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__clkbuf_1
Xhold1204 count_cycle\[30\] VGND VGND VPWR VPWR net2312 sky130_fd_sc_hd__dlygate4sd3_1
X_08832_ cpuregs\[4\]\[19\] cpuregs\[5\]\[19\] cpuregs\[6\]\[19\] cpuregs\[7\]\[19\]
+ net960 net925 VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__mux4_1
XFILLER_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1215 count_instr\[50\] VGND VGND VPWR VPWR net2323 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_29_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_142_2608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold1226 mem_rdata_q\[0\] VGND VGND VPWR VPWR net2334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1237 is_alu_reg_reg VGND VGND VPWR VPWR net2345 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1248 net170 VGND VGND VPWR VPWR net2356 sky130_fd_sc_hd__dlygate4sd3_1
X_08763_ cpuregs\[0\]\[15\] cpuregs\[1\]\[15\] cpuregs\[2\]\[15\] cpuregs\[3\]\[15\]
+ net950 net915 VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__mux4_1
X_05975_ reg_out\[8\] reg_next_pc\[8\] net569 VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__mux2_1
XFILLER_122_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07714_ net2262 _03617_ net995 VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__o21ai_1
Xhold1259 mem_rdata_q\[15\] VGND VGND VPWR VPWR net2367 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_72_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04926_ net895 VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__inv_2
XFILLER_38_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08694_ net889 _04381_ _04380_ net482 VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__o211a_1
X_07645_ net296 net1902 net412 VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1100 VGND VGND VPWR VPWR picorv32_1100/HI trace_data[28] sky130_fd_sc_hd__conb_1
X_07576_ net2012 net311 net418 VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__mux2_1
XFILLER_139_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06527_ _02951_ _02952_ _02954_ _02953_ net726 net722 VGND VGND VPWR VPWR _02955_
+ sky130_fd_sc_hd__mux4_2
XFILLER_15_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09315_ net712 net718 net978 VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__o21ai_1
X_09246_ net1252 net285 net404 VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_11_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06458_ net731 _02887_ VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_38_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05409_ net590 _01992_ _01993_ net855 net708 VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__a32o_1
X_09177_ _04784_ _04788_ VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__or2_1
X_06389_ _02819_ _02820_ net733 VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__mux2_1
XFILLER_31_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08128_ net836 _03936_ _03937_ _03934_ _03935_ VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__o32a_1
XFILLER_107_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08059_ _03870_ _03872_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__xnor2_1
Xoutput46 net46 VGND VGND VPWR VPWR mem_addr[21] sky130_fd_sc_hd__buf_2
Xoutput57 net57 VGND VGND VPWR VPWR mem_addr[31] sky130_fd_sc_hd__buf_2
X_11070_ clknet_leaf_99_clk _01121_ VGND VGND VPWR VPWR mem_rdata_q\[27\] sky130_fd_sc_hd__dfxtp_1
Xoutput35 net35 VGND VGND VPWR VPWR mem_addr[10] sky130_fd_sc_hd__buf_2
Xoutput79 net79 VGND VGND VPWR VPWR mem_la_addr[23] sky130_fd_sc_hd__buf_2
XFILLER_150_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10021_ clknet_leaf_11_clk _00145_ VGND VGND VPWR VPWR cpuregs\[30\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xoutput68 net68 VGND VGND VPWR VPWR mem_la_addr[12] sky130_fd_sc_hd__buf_2
XFILLER_103_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10923_ clknet_leaf_32_clk _00979_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dfxtp_1
XFILLER_71_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10854_ clknet_leaf_103_clk _00912_ VGND VGND VPWR VPWR is_lb_lh_lw_lbu_lhu sky130_fd_sc_hd__dfxtp_2
XFILLER_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10785_ clknet_leaf_87_clk _00844_ VGND VGND VPWR VPWR instr_lui sky130_fd_sc_hd__dfxtp_1
XFILLER_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11406_ clknet_leaf_74_clk _01444_ VGND VGND VPWR VPWR cpuregs\[7\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_93_1817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11337_ clknet_leaf_72_clk _01378_ VGND VGND VPWR VPWR cpuregs\[5\]\[28\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11268_ clknet_leaf_44_clk _01309_ VGND VGND VPWR VPWR cpuregs\[22\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_801 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11199_ clknet_leaf_35_clk _01240_ VGND VGND VPWR VPWR cpuregs\[29\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_10219_ clknet_leaf_26_clk _00343_ VGND VGND VPWR VPWR cpuregs\[14\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_124_2316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05760_ _02159_ _02326_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__nand2_1
XFILLER_48_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05691_ _02167_ net581 net544 _02267_ VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_18_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07430_ net2214 net536 net435 VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__mux2_1
XFILLER_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_102_1957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07361_ _02578_ _03567_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_44_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_102_1968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09100_ net720 net721 VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_44_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06312_ _02716_ net523 net516 _02730_ _02746_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__a41o_1
X_07292_ net1618 net241 net457 VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__mux2_1
X_09031_ cpuregs\[16\]\[30\] cpuregs\[17\]\[30\] cpuregs\[18\]\[30\] cpuregs\[19\]\[30\]
+ net974 net939 VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__mux4_1
X_06243_ net262 net1946 net479 VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_152_2770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_2489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold301 cpuregs\[31\]\[20\] VGND VGND VPWR VPWR net1409 sky130_fd_sc_hd__dlygate4sd3_1
X_06174_ _02627_ _02628_ net565 VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__mux2_2
XFILLER_7_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold334 cpuregs\[15\]\[15\] VGND VGND VPWR VPWR net1442 sky130_fd_sc_hd__dlygate4sd3_1
Xhold312 cpuregs\[26\]\[3\] VGND VGND VPWR VPWR net1420 sky130_fd_sc_hd__dlygate4sd3_1
Xhold323 cpuregs\[31\]\[8\] VGND VGND VPWR VPWR net1431 sky130_fd_sc_hd__dlygate4sd3_1
X_05125_ _01723_ _01727_ _01729_ _01730_ VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__and4_1
Xhold367 cpuregs\[13\]\[25\] VGND VGND VPWR VPWR net1475 sky130_fd_sc_hd__dlygate4sd3_1
Xhold356 cpuregs\[21\]\[23\] VGND VGND VPWR VPWR net1464 sky130_fd_sc_hd__dlygate4sd3_1
Xhold378 cpuregs\[24\]\[20\] VGND VGND VPWR VPWR net1486 sky130_fd_sc_hd__dlygate4sd3_1
Xhold345 cpuregs\[29\]\[1\] VGND VGND VPWR VPWR net1453 sky130_fd_sc_hd__dlygate4sd3_1
X_09933_ clknet_leaf_68_clk _00062_ VGND VGND VPWR VPWR cpuregs\[11\]\[25\] sky130_fd_sc_hd__dfxtp_1
Xfanout803 net804 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__buf_4
XFILLER_131_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout825 net826 VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__clkbuf_4
Xfanout814 decoded_imm_j\[20\] VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__clkbuf_4
X_05056_ net32 net18 net885 VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__mux2_1
Xhold389 cpuregs\[11\]\[9\] VGND VGND VPWR VPWR net1497 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout858 net187 VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__buf_2
XFILLER_98_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_823 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout836 net837 VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__buf_2
X_09864_ net33 net235 VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__nand2_1
Xfanout847 net97 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__clkbuf_8
XFILLER_133_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1023 cpuregs\[9\]\[16\] VGND VGND VPWR VPWR net2131 sky130_fd_sc_hd__dlygate4sd3_1
X_08815_ cpuregs\[12\]\[18\] cpuregs\[13\]\[18\] cpuregs\[14\]\[18\] cpuregs\[15\]\[18\]
+ net960 net925 VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__mux4_1
Xhold1001 cpuregs\[6\]\[17\] VGND VGND VPWR VPWR net2109 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_86_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout869 net179 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__buf_2
Xhold1012 instr_ori VGND VGND VPWR VPWR net2120 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_58_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1067 cpuregs\[10\]\[27\] VGND VGND VPWR VPWR net2175 sky130_fd_sc_hd__dlygate4sd3_1
X_09795_ net245 net2171 net356 VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__mux2_1
XFILLER_100_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1034 cpuregs\[16\]\[18\] VGND VGND VPWR VPWR net2142 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1056 cpuregs\[22\]\[17\] VGND VGND VPWR VPWR net2164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1045 cpuregs\[12\]\[10\] VGND VGND VPWR VPWR net2153 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1078 cpuregs\[9\]\[25\] VGND VGND VPWR VPWR net2186 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05958_ net223 net595 _02479_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__a21o_1
XFILLER_85_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08746_ _04422_ _04423_ net677 VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__mux2_1
Xhold1089 net198 VGND VGND VPWR VPWR net2197 sky130_fd_sc_hd__dlygate4sd3_1
X_05889_ _02107_ _02433_ _02229_ VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__a21o_1
X_08677_ net890 _04364_ net665 VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__a21o_1
XFILLER_54_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07628_ _03567_ _03579_ VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__or2_4
XPHY_EDGE_ROW_46_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07559_ net239 net2096 net424 VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__mux2_1
XFILLER_42_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10570_ clknet_leaf_94_clk _00694_ VGND VGND VPWR VPWR reg_next_pc\[19\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09229_ net1298 net530 net403 VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__mux2_1
XFILLER_147_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold890 cpuregs\[22\]\[28\] VGND VGND VPWR VPWR net1998 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_122_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11122_ clknet_leaf_140_clk _01163_ VGND VGND VPWR VPWR cpuregs\[31\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_89_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11053_ clknet_leaf_111_clk _01104_ VGND VGND VPWR VPWR mem_rdata_q\[10\] sky130_fd_sc_hd__dfxtp_1
X_10004_ clknet_leaf_71_clk _00128_ VGND VGND VPWR VPWR cpuregs\[12\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_131_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_2035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_2024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10906_ clknet_leaf_147_clk _00962_ VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dfxtp_1
XFILLER_32_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10837_ clknet_leaf_88_clk _00896_ VGND VGND VPWR VPWR decoded_imm_j\[19\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10768_ clknet_leaf_20_clk alu_out\[15\] VGND VGND VPWR VPWR alu_out_q\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10699_ clknet_leaf_68_clk _00791_ VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfxtp_1
XFILLER_145_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_2197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06930_ _03335_ _03336_ net653 VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_122_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06861_ _03272_ _03275_ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__or2_1
X_08600_ net901 _04288_ _04287_ net658 VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__o211a_1
X_05812_ _02372_ _02373_ net829 VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__mux2_1
X_06792_ cpuregs\[24\]\[17\] cpuregs\[25\]\[17\] cpuregs\[26\]\[17\] cpuregs\[27\]\[17\]
+ net791 net754 VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__mux4_1
X_09580_ net1856 net315 net378 VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__mux2_1
X_05743_ _02123_ _02312_ VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__nor2_1
X_08531_ _04228_ _04229_ net671 VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__mux2_1
X_08462_ net759 _04193_ _04194_ _04195_ net735 VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__o221a_1
XFILLER_63_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05674_ _01553_ net847 _02143_ _02144_ VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__and4_1
X_07413_ net1868 net289 net440 VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__mux2_1
XFILLER_23_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08393_ count_cycle\[49\] _04140_ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__or2_1
XFILLER_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_2529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07344_ net1384 net300 net447 VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__mux2_1
XFILLER_137_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07275_ net1647 net312 net454 VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__mux2_1
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_2729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09014_ cpuregs\[0\]\[29\] cpuregs\[1\]\[29\] cpuregs\[2\]\[29\] cpuregs\[3\]\[29\]
+ net972 net937 VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__mux4_1
XFILLER_128_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06226_ _02667_ _02670_ net567 VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__mux2_2
Xhold153 cpuregs\[15\]\[16\] VGND VGND VPWR VPWR net1261 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_714 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06157_ reg_pc\[9\] reg_pc\[8\] _02607_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__and3_1
XFILLER_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold142 decoded_rd\[3\] VGND VGND VPWR VPWR net1250 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 cpuregs\[29\]\[11\] VGND VGND VPWR VPWR net1239 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 mem_rdata_q\[8\] VGND VGND VPWR VPWR net1228 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 cpuregs\[26\]\[25\] VGND VGND VPWR VPWR net1283 sky130_fd_sc_hd__dlygate4sd3_1
Xhold186 cpuregs\[31\]\[24\] VGND VGND VPWR VPWR net1294 sky130_fd_sc_hd__dlygate4sd3_1
Xhold164 cpuregs\[21\]\[16\] VGND VGND VPWR VPWR net1272 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05108_ net5 net22 net885 VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__mux2_1
X_06088_ net811 _02556_ VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__nor2_1
Xfanout633 _01573_ VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__clkbuf_4
X_05039_ net694 net699 VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__nor2_2
XFILLER_77_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout622 net625 VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__buf_2
XFILLER_58_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout611 _01598_ VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__clkbuf_4
Xhold197 cpuregs\[25\]\[0\] VGND VGND VPWR VPWR net1305 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout600 _01640_ VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__buf_4
X_09916_ clknet_leaf_14_clk _00045_ VGND VGND VPWR VPWR cpuregs\[11\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xfanout655 net656 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__buf_4
Xfanout666 net667 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout644 net648 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__buf_4
X_09847_ net300 net1678 net345 VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__mux2_1
Xfanout677 net684 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__buf_4
Xfanout699 mem_wordsize\[1\] VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout688 net691 VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_686 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09778_ net316 net2086 net353 VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__mux2_1
XFILLER_18_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08729_ _04402_ _04403_ net900 VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10622_ clknet_leaf_107_clk _00746_ VGND VGND VPWR VPWR count_cycle\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10553_ clknet_leaf_128_clk _00677_ VGND VGND VPWR VPWR reg_next_pc\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_40_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_552 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10484_ clknet_leaf_81_clk _00608_ VGND VGND VPWR VPWR count_instr\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11105_ clknet_leaf_73_clk _01156_ VGND VGND VPWR VPWR cpuregs\[24\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11036_ clknet_leaf_64_clk _01092_ VGND VGND VPWR VPWR cpuregs\[19\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_88_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_786 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05390_ _01974_ _01975_ VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_119_2237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07060_ cpuregs\[4\]\[27\] cpuregs\[5\]\[27\] cpuregs\[6\]\[27\] cpuregs\[7\]\[27\]
+ net805 net768 VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__mux4_1
XFILLER_119_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_132_2437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06011_ reg_out\[26\] reg_next_pc\[26\] net575 VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_132_2448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput203 net203 VGND VGND VPWR VPWR pcpi_rs2[0] sky130_fd_sc_hd__buf_2
Xoutput225 net225 VGND VGND VPWR VPWR pcpi_rs2[2] sky130_fd_sc_hd__buf_2
Xoutput214 net214 VGND VGND VPWR VPWR pcpi_rs2[1] sky130_fd_sc_hd__buf_2
XFILLER_141_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07962_ net687 _03783_ _03784_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__or3_1
X_09701_ net536 net2074 net362 VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__mux2_1
X_07893_ reg_pc\[28\] net505 _03725_ net605 VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__a22o_1
X_06913_ decoded_imm\[22\] net861 VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_52_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_794 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06844_ cpuregs\[8\]\[19\] cpuregs\[9\]\[19\] cpuregs\[10\]\[19\] cpuregs\[11\]\[19\]
+ net795 net758 VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__mux4_1
X_09632_ _03564_ _03582_ VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__nand2_1
X_09563_ net1917 net243 net383 VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__mux2_1
XFILLER_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06775_ decoded_imm\[17\] net868 VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__nand2_1
XFILLER_71_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08514_ net851 net984 _01601_ _01619_ VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__a31o_1
X_09494_ net1732 net256 net392 VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__mux2_1
X_05726_ _02134_ net583 net581 _02133_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_24_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08445_ cpuregs\[4\]\[31\] cpuregs\[5\]\[31\] net794 VGND VGND VPWR VPWR _04179_
+ sky130_fd_sc_hd__mux2_1
X_05657_ _02236_ is_slti_blt_slt VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__and2b_1
XFILLER_24_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08376_ _04130_ _04131_ VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__nor2_1
XFILLER_51_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05588_ net882 net122 VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__or2_1
XFILLER_149_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07327_ latched_rd\[3\] latched_rd\[4\] latched_rd\[2\] VGND VGND VPWR VPWR _03571_
+ sky130_fd_sc_hd__nand3b_1
XFILLER_139_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07258_ net1333 net246 net461 VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__mux2_1
XFILLER_136_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07189_ net1209 net241 net469 VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__mux2_1
X_06209_ _02655_ _02656_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__nor2_1
XFILLER_151_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout441 _03574_ VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_6_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout430 net431 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__clkbuf_8
Xfanout452 net453 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__clkbuf_8
Xfanout463 net464 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__buf_4
Xfanout474 _02601_ VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__clkbuf_2
Xfanout485 net486 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_697 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout496 _01627_ VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_74_667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10605_ clknet_leaf_88_clk _00729_ VGND VGND VPWR VPWR count_cycle\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_80_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10536_ clknet_leaf_94_clk _00660_ VGND VGND VPWR VPWR reg_pc\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_2156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10467_ clknet_leaf_106_clk _00591_ VGND VGND VPWR VPWR count_instr\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10398_ clknet_leaf_146_clk _00522_ VGND VGND VPWR VPWR cpuregs\[20\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11019_ clknet_leaf_7_clk _01075_ VGND VGND VPWR VPWR cpuregs\[19\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_185 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06560_ decoded_imm\[9\] net876 VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__nor2_1
X_05511_ _02090_ VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__inv_2
X_06491_ cpuregs\[28\]\[6\] cpuregs\[29\]\[6\] cpuregs\[30\]\[6\] cpuregs\[31\]\[6\]
+ net785 net749 VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__mux4_1
XFILLER_33_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08230_ _04030_ _04031_ net1001 VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__o21a_1
X_05442_ reg_pc\[30\] decoded_imm\[30\] VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__nand2_1
X_08161_ _03943_ _03948_ _03957_ _03966_ _03967_ VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__a311o_1
X_05373_ net703 net343 _01956_ _01960_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__a31o_1
X_07112_ cpuregs\[24\]\[29\] cpuregs\[25\]\[29\] cpuregs\[26\]\[29\] cpuregs\[27\]\[29\]
+ net805 net768 VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__mux4_1
X_08092_ _03896_ _03902_ net685 VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__a21o_1
XFILLER_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload62 clknet_leaf_38_clk VGND VGND VPWR VPWR clkload62/Y sky130_fd_sc_hd__clkinv_8
X_07043_ net307 _03437_ _03451_ _03428_ VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__a31o_1
Xclkload51 clknet_leaf_26_clk VGND VGND VPWR VPWR clkload51/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload40 clknet_leaf_150_clk VGND VGND VPWR VPWR clkload40/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_115_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload73 clknet_leaf_58_clk VGND VGND VPWR VPWR clkload73/Y sky130_fd_sc_hd__clkinv_8
XTAP_TAPCELL_ROW_54_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload84 clknet_leaf_118_clk VGND VGND VPWR VPWR clkload84/Y sky130_fd_sc_hd__clkinv_4
Xclkload95 clknet_leaf_129_clk VGND VGND VPWR VPWR clkload95/Y sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_149_2720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08994_ cpuregs\[28\]\[28\] cpuregs\[29\]\[28\] cpuregs\[30\]\[28\] cpuregs\[31\]\[28\]
+ net974 net939 VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__mux4_1
XFILLER_115_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_10_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07945_ decoded_imm_j\[6\] _03702_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__and2_1
XFILLER_141_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07876_ _02659_ reg_next_pc\[20\] net572 VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__mux2_2
X_09615_ net299 net2150 net373 VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__mux2_1
XFILLER_56_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06827_ net865 _02740_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__and2_1
X_06758_ net607 _03171_ _03172_ _03174_ _03176_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__a311o_1
X_09546_ net1315 net316 net381 VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05709_ _02170_ _02276_ _02171_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__o21ai_1
X_09477_ net2126 net328 net389 VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__mux2_1
X_08428_ count_cycle\[61\] _04161_ count_cycle\[62\] VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__a21o_1
X_06689_ _03103_ _03104_ net646 VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_726 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload1 clknet_4_1_0_clk VGND VGND VPWR VPWR clkload1/X sky130_fd_sc_hd__clkbuf_8
X_08359_ net2331 _04119_ net980 VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__o21ai_1
XFILLER_50_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11370_ clknet_leaf_47_clk _01408_ VGND VGND VPWR VPWR cpuregs\[6\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_50_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10321_ clknet_leaf_65_clk _00445_ VGND VGND VPWR VPWR cpuregs\[26\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_119_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_842 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10252_ clknet_leaf_35_clk _00376_ VGND VGND VPWR VPWR cpuregs\[27\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10183_ clknet_leaf_21_clk _00307_ VGND VGND VPWR VPWR cpuregs\[9\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout271 _02671_ VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_2
Xfanout260 _02684_ VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__buf_1
XFILLER_121_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout282 _02661_ VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout293 _02650_ VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10519_ clknet_leaf_81_clk _00643_ VGND VGND VPWR VPWR count_instr\[62\] sky130_fd_sc_hd__dfxtp_1
Xhold708 cpuregs\[27\]\[18\] VGND VGND VPWR VPWR net1816 sky130_fd_sc_hd__dlygate4sd3_1
Xhold719 cpuregs\[26\]\[19\] VGND VGND VPWR VPWR net1827 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11499_ clknet_leaf_68_clk _01537_ VGND VGND VPWR VPWR cpuregs\[10\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_115_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07730_ _03628_ _03629_ VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__nor2_1
X_05991_ reg_out\[16\] reg_next_pc\[16\] net574 VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__mux2_1
XFILLER_84_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_127_2369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04942_ mem_state\[0\] mem_state\[1\] VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__or2_1
X_07661_ net718 net848 VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__and2_2
XFILLER_26_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07592_ net1326 net239 net421 VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__mux2_1
XFILLER_65_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06612_ _03034_ _03036_ _03033_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__o21a_1
X_09400_ decoded_imm\[1\] net552 _04863_ _04864_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_140_2569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09331_ _04794_ _04825_ VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__or2_2
X_06543_ cpuregs\[8\]\[8\] cpuregs\[9\]\[8\] cpuregs\[10\]\[8\] cpuregs\[11\]\[8\]
+ net776 net740 VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__mux4_1
XFILLER_80_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_47_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09262_ net850 net635 VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_16_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06474_ net641 _02899_ _02903_ net516 VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__o31ai_1
X_08213_ _03989_ _03999_ _04015_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__or3_1
X_05425_ count_cycle\[28\] net618 VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__or2_1
X_09193_ decoded_imm_j\[9\] _01123_ net333 VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__mux2_1
X_08144_ net689 reg_next_pc\[21\] net546 _03718_ VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__a22o_1
X_05356_ net590 _01943_ _01944_ net860 net708 VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_60_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload140 clknet_leaf_91_clk VGND VGND VPWR VPWR clkload140/X sky130_fd_sc_hd__clkbuf_4
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05287_ reg_pc\[18\] decoded_imm\[18\] VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__xnor2_1
X_08075_ _03887_ _03888_ net836 _03886_ VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__a2bb2o_1
X_07026_ net857 net511 _03357_ net498 VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__o211a_1
XFILLER_102_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold13 cpuregs\[0\]\[1\] VGND VGND VPWR VPWR net1121 sky130_fd_sc_hd__dlygate4sd3_1
X_08977_ cpuregs\[8\]\[27\] cpuregs\[9\]\[27\] cpuregs\[10\]\[27\] cpuregs\[11\]\[27\]
+ net970 net935 VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__mux4_1
Xhold46 net159 VGND VGND VPWR VPWR net1154 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 cpuregs\[0\]\[17\] VGND VGND VPWR VPWR net1132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net160 VGND VGND VPWR VPWR net1143 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 net153 VGND VGND VPWR VPWR net1176 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 count_instr\[63\] VGND VGND VPWR VPWR net1187 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 net139 VGND VGND VPWR VPWR net1165 sky130_fd_sc_hd__dlygate4sd3_1
X_07928_ net687 _03750_ _03751_ _03753_ net559 VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__o311a_1
XTAP_TAPCELL_ROW_67_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07859_ _02627_ reg_next_pc\[12\] net569 VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__mux2_2
XFILLER_56_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10870_ clknet_leaf_150_clk _00926_ VGND VGND VPWR VPWR cpuregs\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_09529_ net1392 net250 net388 VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11422_ clknet_leaf_11_clk _01460_ VGND VGND VPWR VPWR cpuregs\[8\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_111_2104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_733 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11353_ clknet_leaf_0_clk _01391_ VGND VGND VPWR VPWR cpuregs\[6\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_111_2115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11284_ clknet_leaf_148_clk _01325_ VGND VGND VPWR VPWR cpuregs\[4\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10304_ clknet_leaf_151_clk _00428_ VGND VGND VPWR VPWR cpuregs\[26\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10235_ clknet_leaf_125_clk _00359_ VGND VGND VPWR VPWR cpuregs\[27\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout1000 net1002 VGND VGND VPWR VPWR net1000 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_91_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10166_ clknet_leaf_74_clk _00290_ VGND VGND VPWR VPWR cpuregs\[21\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_86_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10097_ clknet_leaf_49_clk _00221_ VGND VGND VPWR VPWR cpuregs\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_2077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_272 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_122_2277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10999_ clknet_leaf_50_clk _01055_ VGND VGND VPWR VPWR cpuregs\[18\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_122_2288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06190_ _02638_ _02641_ net567 VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__mux2_1
X_05210_ _01805_ _01808_ VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__or2_1
XFILLER_129_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05141_ _01744_ _01745_ VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__nor2_1
Xhold527 cpuregs\[23\]\[16\] VGND VGND VPWR VPWR net1635 sky130_fd_sc_hd__dlygate4sd3_1
Xhold516 cpuregs\[12\]\[3\] VGND VGND VPWR VPWR net1624 sky130_fd_sc_hd__dlygate4sd3_1
Xhold505 cpuregs\[25\]\[11\] VGND VGND VPWR VPWR net1613 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold538 cpuregs\[29\]\[20\] VGND VGND VPWR VPWR net1646 sky130_fd_sc_hd__dlygate4sd3_1
Xhold549 cpuregs\[4\]\[18\] VGND VGND VPWR VPWR net1657 sky130_fd_sc_hd__dlygate4sd3_1
X_05072_ _01679_ _01681_ _01673_ VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__a21bo_1
X_08900_ cpuregs\[28\]\[23\] cpuregs\[29\]\[23\] cpuregs\[30\]\[23\] cpuregs\[31\]\[23\]
+ net965 net930 VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__mux4_1
X_09880_ net1129 VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__clkbuf_1
XFILLER_112_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08831_ net902 _04510_ VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__or2_1
Xhold1205 count_cycle\[58\] VGND VGND VPWR VPWR net2313 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1216 instr_bge VGND VGND VPWR VPWR net2324 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_142_2609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1238 mem_rdata_q\[19\] VGND VGND VPWR VPWR net2346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1227 instr_srli VGND VGND VPWR VPWR net2335 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1249 net168 VGND VGND VPWR VPWR net2357 sky130_fd_sc_hd__dlygate4sd3_1
X_08762_ cpuregs\[4\]\[15\] cpuregs\[5\]\[15\] cpuregs\[6\]\[15\] cpuregs\[7\]\[15\]
+ net951 net916 VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__mux4_1
X_05974_ net200 _02489_ net634 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__mux2_1
X_07713_ count_instr\[19\] count_instr\[18\] count_instr\[17\] _03613_ VGND VGND VPWR
+ VPWR _03618_ sky130_fd_sc_hd__and4_2
X_04925_ net899 VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__inv_2
X_08693_ _04369_ _04370_ _04374_ _04375_ net669 net664 VGND VGND VPWR VPWR _04381_
+ sky130_fd_sc_hd__mux4_1
X_07644_ net300 net1579 net411 VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xpicorv32_1101 VGND VGND VPWR VPWR picorv32_1101/HI trace_data[29] sky130_fd_sc_hd__conb_1
X_07575_ net1502 net314 net419 VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__mux2_1
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09314_ net133 net407 _04816_ _04204_ VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_62_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06526_ _02949_ _02950_ net644 VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__mux2_1
XFILLER_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09245_ net1729 net287 net404 VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__mux2_1
X_06457_ cpuregs\[16\]\[5\] cpuregs\[17\]\[5\] cpuregs\[18\]\[5\] cpuregs\[19\]\[5\]
+ net776 net740 VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__mux4_1
X_05408_ count_cycle\[27\] net618 VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__or2_1
X_09176_ _04784_ _04788_ VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__nor2_1
X_06388_ cpuregs\[28\]\[3\] cpuregs\[29\]\[3\] cpuregs\[30\]\[3\] cpuregs\[31\]\[3\]
+ net785 net749 VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__mux4_1
XFILLER_147_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05339_ _01926_ _01928_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__xnor2_1
X_08127_ _03717_ _03928_ VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__nor2_1
XFILLER_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08058_ _03858_ _03862_ _03870_ _03860_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__o211a_1
Xoutput47 net47 VGND VGND VPWR VPWR mem_addr[22] sky130_fd_sc_hd__buf_2
X_07009_ cpuregs\[20\]\[25\] cpuregs\[21\]\[25\] cpuregs\[22\]\[25\] cpuregs\[23\]\[25\]
+ net804 net767 VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__mux4_1
Xoutput36 net36 VGND VGND VPWR VPWR mem_addr[11] sky130_fd_sc_hd__buf_2
Xoutput58 net58 VGND VGND VPWR VPWR mem_addr[3] sky130_fd_sc_hd__buf_2
Xoutput69 net69 VGND VGND VPWR VPWR mem_la_addr[13] sky130_fd_sc_hd__buf_2
X_10020_ clknet_leaf_12_clk _00144_ VGND VGND VPWR VPWR cpuregs\[30\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_73_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10922_ clknet_leaf_32_clk _00978_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dfxtp_1
XFILLER_91_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10853_ clknet_leaf_92_clk _00001_ VGND VGND VPWR VPWR is_lui_auipc_jal sky130_fd_sc_hd__dfxtp_2
X_10784_ clknet_leaf_89_clk alu_out\[31\] VGND VGND VPWR VPWR alu_out_q\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11405_ clknet_leaf_72_clk _01443_ VGND VGND VPWR VPWR cpuregs\[7\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_11336_ clknet_leaf_70_clk _01377_ VGND VGND VPWR VPWR cpuregs\[5\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_93_1818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11267_ clknet_leaf_36_clk _01308_ VGND VGND VPWR VPWR cpuregs\[22\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10218_ clknet_leaf_34_clk _00342_ VGND VGND VPWR VPWR cpuregs\[14\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_11198_ clknet_leaf_26_clk _01239_ VGND VGND VPWR VPWR cpuregs\[29\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_857 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10149_ clknet_leaf_10_clk _00273_ VGND VGND VPWR VPWR cpuregs\[21\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_124_2317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05690_ _02169_ _02266_ VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_18_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07360_ net1667 net238 net447 VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__mux2_1
XFILLER_50_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06311_ net608 _02741_ _02742_ _02745_ net508 VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_44_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07291_ net1264 net246 net457 VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_139_2560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09030_ cpuregs\[24\]\[30\] cpuregs\[25\]\[30\] cpuregs\[26\]\[30\] cpuregs\[27\]\[30\]
+ net974 net939 VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__mux4_1
X_06242_ _02680_ _02683_ net568 VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_152_2760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06173_ reg_pc\[12\] _02623_ VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__xor2_1
Xhold302 cpuregs\[31\]\[1\] VGND VGND VPWR VPWR net1410 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_152_2771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold313 cpuregs\[31\]\[26\] VGND VGND VPWR VPWR net1421 sky130_fd_sc_hd__dlygate4sd3_1
Xhold335 cpuregs\[28\]\[25\] VGND VGND VPWR VPWR net1443 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold324 cpuregs\[27\]\[11\] VGND VGND VPWR VPWR net1432 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05124_ reg_pc\[5\] decoded_imm\[5\] _01703_ _01704_ _01702_ VGND VGND VPWR VPWR
+ _01730_ sky130_fd_sc_hd__a221o_1
Xhold357 cpuregs\[1\]\[22\] VGND VGND VPWR VPWR net1465 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09932_ clknet_leaf_51_clk _00061_ VGND VGND VPWR VPWR cpuregs\[11\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_116_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold368 cpuregs\[27\]\[13\] VGND VGND VPWR VPWR net1476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold346 cpuregs\[1\]\[10\] VGND VGND VPWR VPWR net1454 sky130_fd_sc_hd__dlygate4sd3_1
X_05055_ _01662_ _01666_ _01664_ VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__o21a_1
Xhold379 cpuregs\[20\]\[29\] VGND VGND VPWR VPWR net1487 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout804 net808 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__buf_4
Xfanout815 net818 VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__buf_2
X_09863_ net237 net2162 net347 VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__mux2_1
XFILLER_100_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout837 net839 VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__buf_2
Xfanout826 net827 VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__clkbuf_4
Xfanout848 decoder_trigger VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__buf_2
X_09794_ net247 net2116 net356 VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__mux2_1
Xhold1024 cpuregs\[9\]\[22\] VGND VGND VPWR VPWR net2132 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_133_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08814_ net902 _04494_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__or2_1
Xfanout859 net860 VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__buf_2
Xhold1002 cpuregs\[18\]\[31\] VGND VGND VPWR VPWR net2110 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1013 cpu_state\[0\] VGND VGND VPWR VPWR net2121 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1057 cpuregs\[6\]\[31\] VGND VGND VPWR VPWR net2165 sky130_fd_sc_hd__dlygate4sd3_1
X_08745_ net900 _04426_ net660 VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__o21a_1
Xhold1035 cpuregs\[19\]\[7\] VGND VGND VPWR VPWR net2143 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1046 cpuregs\[19\]\[5\] VGND VGND VPWR VPWR net2154 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1068 cpuregs\[19\]\[21\] VGND VGND VPWR VPWR net2176 sky130_fd_sc_hd__dlygate4sd3_1
X_05957_ net222 net594 _02478_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__a21o_1
Xhold1079 cpuregs\[25\]\[18\] VGND VGND VPWR VPWR net2187 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_94_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05888_ _02102_ net582 _02245_ _02104_ _02440_ VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__o221a_1
X_08676_ net901 _04360_ _04359_ net659 VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__o211a_1
XFILLER_26_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07627_ net1512 net238 net415 VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__mux2_1
XFILLER_53_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07558_ net243 net2199 net424 VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__mux2_1
X_06509_ _02909_ _02911_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__nand2_1
X_07489_ net1751 net254 net433 VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__mux2_1
XFILLER_10_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09228_ net1332 net536 net403 VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__mux2_1
XFILLER_148_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09159_ net2246 net500 _04756_ _04773_ VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__a22o_1
XFILLER_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_2_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11121_ clknet_leaf_126_clk _01162_ VGND VGND VPWR VPWR cpuregs\[31\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xhold891 cpuregs\[9\]\[21\] VGND VGND VPWR VPWR net1999 sky130_fd_sc_hd__dlygate4sd3_1
Xhold880 cpuregs\[16\]\[14\] VGND VGND VPWR VPWR net1988 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11052_ clknet_leaf_111_clk _01103_ VGND VGND VPWR VPWR mem_rdata_q\[9\] sky130_fd_sc_hd__dfxtp_1
X_10003_ clknet_leaf_70_clk _00127_ VGND VGND VPWR VPWR cpuregs\[12\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_106_2025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10905_ clknet_leaf_6_clk _00961_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dfxtp_1
X_10836_ clknet_leaf_87_clk _00895_ VGND VGND VPWR VPWR decoded_imm_j\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10767_ clknet_leaf_19_clk alu_out\[14\] VGND VGND VPWR VPWR alu_out_q\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10698_ clknet_leaf_82_clk _00790_ VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_117_2198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11319_ clknet_leaf_13_clk _01360_ VGND VGND VPWR VPWR cpuregs\[5\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06860_ _03273_ _03274_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__nor2_1
X_05811_ _02115_ _02206_ _02209_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__o21bai_1
X_06791_ cpuregs\[28\]\[17\] cpuregs\[29\]\[17\] cpuregs\[30\]\[17\] cpuregs\[31\]\[17\]
+ net791 net754 VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__mux4_1
XFILLER_83_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05742_ _02122_ net578 net583 VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__o21ba_1
XFILLER_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08530_ cpuregs\[24\]\[0\] cpuregs\[25\]\[0\] cpuregs\[26\]\[0\] cpuregs\[27\]\[0\]
+ net945 net910 VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__mux4_1
X_08461_ cpuregs\[23\]\[31\] net794 net759 VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__a21bo_1
X_05673_ _02145_ net578 _02251_ VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__o21ai_1
XFILLER_24_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07412_ net1319 net294 net440 VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__mux2_1
X_08392_ _04140_ _04141_ VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__nor2_1
XFILLER_148_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_137_2519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07343_ net1330 net309 net447 VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__mux2_1
XFILLER_50_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07274_ net1649 net316 net454 VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__mux2_1
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09013_ cpuregs\[4\]\[29\] cpuregs\[5\]\[29\] cpuregs\[6\]\[29\] cpuregs\[7\]\[29\]
+ net972 net937 VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__mux4_1
XFILLER_128_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06225_ _02668_ _02669_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__nor2_1
Xhold110 cpuregs\[30\]\[29\] VGND VGND VPWR VPWR net1218 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06156_ reg_pc\[8\] _02607_ reg_pc\[9\] VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__a21oi_1
Xhold121 cpuregs\[29\]\[4\] VGND VGND VPWR VPWR net1229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 cpuregs\[31\]\[9\] VGND VGND VPWR VPWR net1251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 cpuregs\[13\]\[11\] VGND VGND VPWR VPWR net1240 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold154 cpuregs\[24\]\[25\] VGND VGND VPWR VPWR net1262 sky130_fd_sc_hd__dlygate4sd3_1
X_06087_ _02551_ _02555_ net541 _02547_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__a211o_1
Xhold165 cpuregs\[29\]\[2\] VGND VGND VPWR VPWR net1273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold176 cpuregs\[2\]\[9\] VGND VGND VPWR VPWR net1284 sky130_fd_sc_hd__dlygate4sd3_1
X_05107_ _01707_ _01713_ _01714_ VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__or3_1
XFILLER_132_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout623 net624 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__buf_2
Xfanout601 _01639_ VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__clkbuf_4
Xfanout612 _01598_ VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__clkbuf_2
X_05038_ net700 _01622_ _01635_ _01636_ _01651_ VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__a32o_1
Xhold198 cpuregs\[31\]\[7\] VGND VGND VPWR VPWR net1306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold187 cpuregs\[14\]\[2\] VGND VGND VPWR VPWR net1295 sky130_fd_sc_hd__dlygate4sd3_1
X_09915_ clknet_leaf_150_clk _00044_ VGND VGND VPWR VPWR cpuregs\[11\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xfanout656 net657 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__buf_4
Xfanout667 net668 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__clkbuf_8
XFILLER_86_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09846_ net309 net2195 net345 VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout634 _01570_ VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__buf_4
Xfanout645 net648 VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__buf_2
Xfanout678 net684 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__buf_2
XFILLER_86_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout689 net690 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__clkbuf_4
X_06989_ _03388_ _03389_ _03392_ _03393_ net654 net642 VGND VGND VPWR VPWR _03400_
+ sky130_fd_sc_hd__mux4_1
XFILLER_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09777_ net320 net1662 net353 VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__mux2_1
X_08728_ _04408_ _04412_ _04413_ net890 net896 VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_1_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08659_ _04347_ _04348_ net482 _04345_ VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__o211a_1
XFILLER_53_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10621_ clknet_leaf_107_clk _00745_ VGND VGND VPWR VPWR count_cycle\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10552_ clknet_leaf_129_clk _00676_ VGND VGND VPWR VPWR reg_next_pc\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_40_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10483_ clknet_leaf_83_clk _00607_ VGND VGND VPWR VPWR count_instr\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_118_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11104_ clknet_leaf_75_clk _01155_ VGND VGND VPWR VPWR cpuregs\[24\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11035_ clknet_leaf_72_clk _01091_ VGND VGND VPWR VPWR cpuregs\[19\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_104_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10819_ clknet_leaf_96_clk _00878_ VGND VGND VPWR VPWR instr_or sky130_fd_sc_hd__dfxtp_1
XFILLER_13_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_119_2238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06010_ net188 _02507_ net637 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_132_2438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput226 net226 VGND VGND VPWR VPWR pcpi_rs2[30] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_132_2449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput215 net215 VGND VGND VPWR VPWR pcpi_rs2[20] sky130_fd_sc_hd__buf_2
Xoutput204 net204 VGND VGND VPWR VPWR pcpi_rs2[10] sky130_fd_sc_hd__buf_2
XFILLER_114_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07961_ _03780_ _03781_ _03782_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__and3_1
XFILLER_114_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06912_ decoded_imm\[22\] net861 VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__nand2_1
X_09700_ net538 net1347 net362 VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__mux2_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07892_ _02693_ reg_next_pc\[28\] _02483_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__mux2_2
XFILLER_114_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_74_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09631_ net236 net2024 net375 VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__mux2_1
XFILLER_95_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06843_ cpuregs\[12\]\[19\] cpuregs\[13\]\[19\] cpuregs\[14\]\[19\] cpuregs\[15\]\[19\]
+ net795 net758 VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__mux4_1
XFILLER_67_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09562_ net1595 net249 net383 VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__mux2_1
X_06774_ net306 _03177_ _03192_ _03162_ VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__a31o_1
XFILLER_82_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08513_ _02241_ _02732_ _04214_ _04213_ VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__a31o_1
X_05725_ _02135_ _02295_ net543 VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__a21o_1
XFILLER_36_562 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09493_ net1262 net260 net392 VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__mux2_1
X_08444_ net735 _04173_ _04177_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__a21oi_1
X_05656_ _02096_ _02235_ _02177_ VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__a21oi_2
XFILLER_51_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08375_ net2304 _04129_ net985 VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__o21ai_1
X_05587_ net882 net122 VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__nand2_1
XFILLER_11_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07326_ net1691 net238 net452 VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_83_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07257_ net1401 net248 net461 VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__mux2_1
X_07188_ net1235 net246 net469 VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__mux2_1
XFILLER_133_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06208_ reg_pc\[19\] reg_pc\[18\] _02648_ VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__and3_1
X_06139_ _02597_ _02600_ net565 VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__mux2_1
XFILLER_133_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_92_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout420 net421 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__clkbuf_8
XFILLER_59_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout431 _03577_ VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__buf_4
Xfanout464 net465 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__clkbuf_8
XFILLER_86_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_805 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout453 _03570_ VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__clkbuf_8
Xfanout442 net443 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__clkbuf_8
Xfanout475 _02601_ VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__clkbuf_2
X_09829_ net240 net2183 net352 VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__mux2_1
Xfanout497 net498 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__clkbuf_4
Xfanout486 net487 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_679 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_147_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_147_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_120_50 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10604_ clknet_leaf_88_clk _00728_ VGND VGND VPWR VPWR count_cycle\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_127_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10535_ clknet_leaf_59_clk _00659_ VGND VGND VPWR VPWR reg_pc\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10466_ clknet_leaf_106_clk _00590_ VGND VGND VPWR VPWR count_instr\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_142_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_394 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10397_ clknet_leaf_139_clk _00521_ VGND VGND VPWR VPWR cpuregs\[20\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11018_ clknet_leaf_7_clk _01074_ VGND VGND VPWR VPWR cpuregs\[19\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_92_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_882 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_138_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_138_clk sky130_fd_sc_hd__clkbuf_8
X_05510_ net858 net219 VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__nor2_1
X_06490_ cpuregs\[24\]\[6\] cpuregs\[25\]\[6\] cpuregs\[26\]\[6\] cpuregs\[27\]\[6\]
+ net785 net749 VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__mux4_1
XFILLER_33_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05441_ _02022_ _02023_ VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__or2_1
XFILLER_33_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08160_ _03718_ _03719_ net812 VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__o21a_1
XFILLER_14_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07111_ net854 net512 _03434_ net498 VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__o211a_1
X_05372_ net590 _01958_ _01959_ net858 net710 VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__a32o_1
X_08091_ _03896_ _03902_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__or2_1
X_07042_ reg_pc\[26\] net562 _03450_ net519 net522 VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__a221o_1
XFILLER_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload52 clknet_leaf_27_clk VGND VGND VPWR VPWR clkload52/Y sky130_fd_sc_hd__clkinv_8
Xclkload41 clknet_leaf_17_clk VGND VGND VPWR VPWR clkload41/Y sky130_fd_sc_hd__clkinv_4
Xclkload30 clknet_leaf_139_clk VGND VGND VPWR VPWR clkload30/Y sky130_fd_sc_hd__inv_6
Xclkload63 clknet_leaf_39_clk VGND VGND VPWR VPWR clkload63/Y sky130_fd_sc_hd__inv_12
XFILLER_115_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload74 clknet_leaf_59_clk VGND VGND VPWR VPWR clkload74/Y sky130_fd_sc_hd__clkinv_4
Xclkload96 clknet_leaf_131_clk VGND VGND VPWR VPWR clkload96/Y sky130_fd_sc_hd__inv_6
Xclkload85 clknet_leaf_119_clk VGND VGND VPWR VPWR clkload85/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_149_2710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_149_2721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08993_ cpuregs\[8\]\[28\] cpuregs\[9\]\[28\] cpuregs\[10\]\[28\] cpuregs\[11\]\[28\]
+ net972 net937 VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__mux4_1
XFILLER_141_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_515 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07944_ decoded_imm_j\[6\] _03702_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__or2_1
X_07875_ reg_pc\[19\] net504 _03716_ net604 VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__a22o_1
XFILLER_84_900 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06826_ net867 _03242_ net306 VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__mux2_1
XFILLER_83_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09614_ net308 net1990 net375 VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__mux2_1
XFILLER_55_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06757_ net489 _03099_ _03175_ net524 VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__a31o_1
XFILLER_24_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09545_ net1505 net321 net381 VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_129_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_129_clk sky130_fd_sc_hd__clkbuf_8
X_06688_ _03101_ _03102_ net646 VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__mux2_1
X_05708_ _02280_ _02281_ _02282_ VGND VGND VPWR VPWR alu_out\[5\] sky130_fd_sc_hd__or3_1
X_09476_ net1436 net336 net389 VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__mux2_1
X_08427_ net2337 _04161_ _04163_ VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__o21a_1
X_05639_ _02068_ _02218_ VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_65_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_738 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08358_ count_cycle\[34\] count_cycle\[35\] count_cycle\[36\] _04115_ VGND VGND VPWR
+ VPWR _04120_ sky130_fd_sc_hd__and4_1
Xclkload2 clknet_4_3_0_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_6
XFILLER_109_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07309_ net1660 net311 net451 VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__mux2_1
X_08289_ count_cycle\[10\] _04075_ net985 VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__o21ai_1
X_10320_ clknet_leaf_52_clk _00444_ VGND VGND VPWR VPWR cpuregs\[26\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10251_ clknet_leaf_22_clk _00375_ VGND VGND VPWR VPWR cpuregs\[27\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_854 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10182_ clknet_leaf_11_clk _00306_ VGND VGND VPWR VPWR cpuregs\[9\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_59_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout250 _02695_ VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_2
XFILLER_132_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout261 _02684_ VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_2
Xfanout272 _02671_ VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__buf_1
Xfanout283 net284 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_2
XFILLER_47_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout294 _02650_ VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_1
XFILLER_47_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_141_Right_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_771 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10518_ clknet_leaf_81_clk _00642_ VGND VGND VPWR VPWR count_instr\[61\] sky130_fd_sc_hd__dfxtp_1
Xhold709 cpuregs\[16\]\[31\] VGND VGND VPWR VPWR net1817 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_10_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11498_ clknet_leaf_49_clk _01536_ VGND VGND VPWR VPWR cpuregs\[10\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10449_ clknet_leaf_50_clk _00573_ VGND VGND VPWR VPWR cpuregs\[17\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05990_ net871 _02497_ net636 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__mux2_2
XFILLER_97_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04941_ mem_state\[0\] mem_state\[1\] VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__nor2_1
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_2640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_148_Left_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07660_ net238 net1879 net412 VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__mux2_1
XFILLER_65_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07591_ net1321 net243 net421 VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__mux2_1
XFILLER_53_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06611_ net641 _03035_ net638 VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__a21o_1
X_09330_ net810 is_sb_sh_sw VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__or2_2
X_06542_ cpuregs\[12\]\[8\] cpuregs\[13\]\[8\] cpuregs\[14\]\[8\] cpuregs\[15\]\[8\]
+ net776 net740 VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__mux4_1
X_09261_ net810 _01582_ net499 VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__o21a_1
XFILLER_21_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08212_ _03993_ _04001_ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_47_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06473_ net644 _02900_ _02902_ net638 VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__o211a_1
X_05424_ count_instr\[28\] net821 net624 _02007_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__a211o_1
X_09192_ mem_rdata_q\[29\] net22 net613 VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__mux2_1
X_08143_ net557 _03951_ VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__nor2_1
X_05355_ count_cycle\[23\] net618 VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_60_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload130 clknet_leaf_72_clk VGND VGND VPWR VPWR clkload130/Y sky130_fd_sc_hd__clkinv_2
X_08074_ _03712_ _03876_ net685 VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_60_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07025_ net194 net514 VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__or2_1
X_05286_ _01879_ _01880_ VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__or2_1
Xclkload141 clknet_leaf_92_clk VGND VGND VPWR VPWR clkload141/X sky130_fd_sc_hd__clkbuf_8
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold14 cpuregs\[0\]\[13\] VGND VGND VPWR VPWR net1122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 cpuregs\[0\]\[28\] VGND VGND VPWR VPWR net1133 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_152_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold36 cpuregs\[0\]\[27\] VGND VGND VPWR VPWR net1144 sky130_fd_sc_hd__dlygate4sd3_1
X_08976_ cpuregs\[24\]\[27\] cpuregs\[25\]\[27\] cpuregs\[26\]\[27\] cpuregs\[27\]\[27\]
+ net971 net936 VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__mux4_1
Xhold47 net158 VGND VGND VPWR VPWR net1155 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_760 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold58 net154 VGND VGND VPWR VPWR net1166 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_56_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold69 net36 VGND VGND VPWR VPWR net1177 sky130_fd_sc_hd__dlygate4sd3_1
X_07927_ net687 _03752_ VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__nand2_1
XFILLER_72_903 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07858_ reg_pc\[11\] net502 _03707_ net603 VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__a22o_1
XFILLER_28_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06809_ net861 net513 VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__or2_1
X_07789_ _03666_ net988 _03665_ VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__and3b_1
X_09528_ net1674 net251 net388 VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__mux2_1
XFILLER_71_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09459_ net263 net2213 net394 VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_844 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11421_ clknet_leaf_12_clk _01459_ VGND VGND VPWR VPWR cpuregs\[8\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11352_ clknet_leaf_2_clk _01390_ VGND VGND VPWR VPWR cpuregs\[6\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_111_2105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10303_ clknet_leaf_148_clk _00427_ VGND VGND VPWR VPWR cpuregs\[26\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11283_ clknet_leaf_146_clk _01324_ VGND VGND VPWR VPWR cpuregs\[4\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_152_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10234_ clknet_leaf_117_clk _00358_ VGND VGND VPWR VPWR cpuregs\[27\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_10165_ clknet_leaf_74_clk _00289_ VGND VGND VPWR VPWR cpuregs\[21\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1001 net1002 VGND VGND VPWR VPWR net1001 sky130_fd_sc_hd__buf_2
XFILLER_79_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10096_ clknet_leaf_53_clk _00220_ VGND VGND VPWR VPWR cpuregs\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_2078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_122_2289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10998_ clknet_leaf_52_clk _01054_ VGND VGND VPWR VPWR cpuregs\[18\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_62_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05140_ _01741_ _01742_ _01743_ VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__nor3_1
XFILLER_143_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold506 cpuregs\[14\]\[30\] VGND VGND VPWR VPWR net1614 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold517 cpuregs\[8\]\[1\] VGND VGND VPWR VPWR net1625 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold539 cpuregs\[2\]\[13\] VGND VGND VPWR VPWR net1647 sky130_fd_sc_hd__dlygate4sd3_1
Xhold528 cpuregs\[23\]\[10\] VGND VGND VPWR VPWR net1636 sky130_fd_sc_hd__dlygate4sd3_1
X_05071_ reg_pc\[2\] decoded_imm\[2\] VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__or2_1
XFILLER_112_610 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08830_ cpuregs\[24\]\[19\] cpuregs\[25\]\[19\] cpuregs\[26\]\[19\] cpuregs\[27\]\[19\]
+ net961 net926 VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__mux4_1
Xhold1206 count_instr\[26\] VGND VGND VPWR VPWR net2314 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_85_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1217 net145 VGND VGND VPWR VPWR net2325 sky130_fd_sc_hd__dlygate4sd3_1
X_08761_ cpuregs\[12\]\[15\] cpuregs\[13\]\[15\] cpuregs\[14\]\[15\] cpuregs\[15\]\[15\]
+ net951 net916 VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__mux4_1
Xhold1239 net167 VGND VGND VPWR VPWR net2347 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05973_ reg_out\[7\] reg_next_pc\[7\] net570 VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__mux2_1
Xhold1228 count_instr\[38\] VGND VGND VPWR VPWR net2336 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_122_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07712_ _03617_ net995 _03616_ VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__and3b_1
X_04924_ net706 VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__inv_2
XFILLER_38_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08692_ net664 _04378_ _04379_ _04373_ net658 VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__a221o_1
X_07643_ net309 net1755 net412 VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__mux2_1
XFILLER_65_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09313_ net2356 net487 VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__or2_1
X_07574_ net1510 net319 net418 VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__mux2_1
XFILLER_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xpicorv32_1102 VGND VGND VPWR VPWR picorv32_1102/HI trace_data[30] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_62_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06525_ _02945_ _02946_ net645 VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_60_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_60_clk sky130_fd_sc_hd__clkbuf_8
X_09244_ net1336 net292 net404 VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__mux2_1
XFILLER_21_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06456_ net879 net515 _02885_ net495 VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__o211a_1
X_05407_ count_instr\[27\] net821 net624 _01991_ VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__a211o_1
X_09175_ mem_rdata_q\[23\] mem_rdata_q\[22\] mem_rdata_q\[20\] mem_rdata_q\[21\] VGND
+ VGND VPWR VPWR _04788_ sky130_fd_sc_hd__or4b_1
XFILLER_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08126_ _03716_ _03717_ _03914_ VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__and3_1
X_06387_ cpuregs\[24\]\[3\] cpuregs\[25\]\[3\] cpuregs\[26\]\[3\] cpuregs\[27\]\[3\]
+ net786 net750 VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__mux4_1
XFILLER_119_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05338_ _01914_ _01917_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__nand2_1
X_05269_ net8 net597 net587 VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__a21o_1
X_08057_ _03858_ _03862_ _03860_ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput48 net48 VGND VGND VPWR VPWR mem_addr[23] sky130_fd_sc_hd__buf_2
X_07008_ cpuregs\[0\]\[25\] cpuregs\[1\]\[25\] cpuregs\[2\]\[25\] cpuregs\[3\]\[25\]
+ net803 net766 VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__mux4_1
XFILLER_122_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput37 net37 VGND VGND VPWR VPWR mem_addr[12] sky130_fd_sc_hd__buf_2
XFILLER_1_704 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput59 net59 VGND VGND VPWR VPWR mem_addr[4] sky130_fd_sc_hd__buf_2
XFILLER_88_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08959_ cpuregs\[4\]\[26\] cpuregs\[5\]\[26\] cpuregs\[6\]\[26\] cpuregs\[7\]\[26\]
+ net966 net931 VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__mux4_1
XFILLER_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10921_ clknet_leaf_32_clk _00977_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dfxtp_1
XFILLER_57_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10852_ clknet_leaf_100_clk _00911_ VGND VGND VPWR VPWR decoded_imm\[0\] sky130_fd_sc_hd__dfxtp_1
X_10783_ clknet_leaf_90_clk alu_out\[30\] VGND VGND VPWR VPWR alu_out_q\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_51_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_51_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_13_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11404_ clknet_leaf_70_clk _01442_ VGND VGND VPWR VPWR cpuregs\[7\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_11335_ clknet_leaf_48_clk _01376_ VGND VGND VPWR VPWR cpuregs\[5\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_93_1819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11266_ clknet_leaf_39_clk _01307_ VGND VGND VPWR VPWR cpuregs\[22\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10217_ clknet_leaf_25_clk _00341_ VGND VGND VPWR VPWR cpuregs\[14\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_11197_ clknet_leaf_45_clk _01238_ VGND VGND VPWR VPWR cpuregs\[29\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10148_ clknet_leaf_4_clk _00272_ VGND VGND VPWR VPWR cpuregs\[21\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_124_2318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10079_ clknet_leaf_152_clk _00203_ VGND VGND VPWR VPWR cpuregs\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07290_ net1393 net247 net457 VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_42_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_42_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_102_1959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06310_ net886 net496 net491 net881 VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_139_2561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06241_ _02681_ _02682_ VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_152_2761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06172_ reg_out\[12\] alu_out_q\[12\] net841 VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__mux2_1
XFILLER_8_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold314 cpuregs\[23\]\[24\] VGND VGND VPWR VPWR net1422 sky130_fd_sc_hd__dlygate4sd3_1
Xhold303 cpuregs\[2\]\[10\] VGND VGND VPWR VPWR net1411 sky130_fd_sc_hd__dlygate4sd3_1
Xhold325 cpuregs\[15\]\[4\] VGND VGND VPWR VPWR net1433 sky130_fd_sc_hd__dlygate4sd3_1
X_05123_ reg_pc\[6\] decoded_imm\[6\] VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__or2_1
X_09931_ clknet_leaf_47_clk _00060_ VGND VGND VPWR VPWR cpuregs\[11\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold358 net53 VGND VGND VPWR VPWR net1466 sky130_fd_sc_hd__dlygate4sd3_1
Xhold369 cpuregs\[5\]\[16\] VGND VGND VPWR VPWR net1477 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold347 cpuregs\[31\]\[19\] VGND VGND VPWR VPWR net1455 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold336 cpuregs\[23\]\[17\] VGND VGND VPWR VPWR net1444 sky130_fd_sc_hd__dlygate4sd3_1
X_05054_ count_instr\[32\] net815 count_cycle\[0\] net622 _01665_ VGND VGND VPWR VPWR
+ _01666_ sky130_fd_sc_hd__a221o_1
Xfanout805 net808 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__buf_4
XFILLER_132_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout816 net817 VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__clkbuf_4
X_09862_ net240 net2139 net348 VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__mux2_1
XFILLER_98_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_86_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout827 instr_rdcycleh VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__buf_2
Xfanout838 net839 VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__clkbuf_4
Xfanout849 decoder_trigger VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__clkbuf_2
X_09793_ net252 net1699 net356 VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__mux2_1
XFILLER_133_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1003 cpuregs\[28\]\[18\] VGND VGND VPWR VPWR net2111 sky130_fd_sc_hd__dlygate4sd3_1
X_08813_ cpuregs\[8\]\[18\] cpuregs\[9\]\[18\] cpuregs\[10\]\[18\] cpuregs\[11\]\[18\]
+ net959 net924 VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__mux4_1
XFILLER_85_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold1014 cpuregs\[3\]\[4\] VGND VGND VPWR VPWR net2122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1036 cpuregs\[22\]\[21\] VGND VGND VPWR VPWR net2144 sky130_fd_sc_hd__dlygate4sd3_1
X_05956_ net221 net595 _02477_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__a21o_1
XFILLER_86_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08744_ cpuregs\[8\]\[14\] cpuregs\[9\]\[14\] cpuregs\[10\]\[14\] cpuregs\[11\]\[14\]
+ net948 net913 VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__mux4_1
Xhold1025 cpuregs\[19\]\[4\] VGND VGND VPWR VPWR net2133 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1058 cpuregs\[18\]\[6\] VGND VGND VPWR VPWR net2166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1047 cpuregs\[10\]\[5\] VGND VGND VPWR VPWR net2155 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1069 cpuregs\[11\]\[29\] VGND VGND VPWR VPWR net2177 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_66_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05887_ _02103_ net586 VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__nand2_1
X_08675_ _04354_ _04355_ net673 VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07626_ net2193 net240 net416 VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__mux2_1
X_07557_ net249 net2083 net424 VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_33_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_33_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_22_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06508_ _02934_ _02935_ VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__nand2b_1
X_07488_ net1488 net257 net432 VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__mux2_1
XFILLER_139_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06439_ _02869_ _02868_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__and2b_1
X_09227_ net1383 net538 net402 VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__mux2_1
XFILLER_148_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09158_ net1723 net501 _04755_ _04776_ VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__a22o_1
XFILLER_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08109_ decoded_imm_j\[19\] _03716_ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_75_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09089_ _04739_ _04741_ _04742_ _02515_ net1120 VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_75_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11120_ clknet_leaf_125_clk _01161_ VGND VGND VPWR VPWR cpuregs\[31\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold881 cpuregs\[18\]\[14\] VGND VGND VPWR VPWR net1989 sky130_fd_sc_hd__dlygate4sd3_1
Xhold870 cpuregs\[17\]\[0\] VGND VGND VPWR VPWR net1978 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_49_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold892 cpuregs\[23\]\[3\] VGND VGND VPWR VPWR net2000 sky130_fd_sc_hd__dlygate4sd3_1
X_11051_ clknet_leaf_111_clk _01102_ VGND VGND VPWR VPWR mem_rdata_q\[8\] sky130_fd_sc_hd__dfxtp_1
X_10002_ clknet_leaf_49_clk _00126_ VGND VGND VPWR VPWR cpuregs\[12\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_89_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_106_2026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_103_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10904_ clknet_leaf_145_clk _00960_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dfxtp_1
XFILLER_45_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10835_ clknet_leaf_96_clk _00894_ VGND VGND VPWR VPWR decoded_imm_j\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_24_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
X_10766_ clknet_leaf_19_clk alu_out\[13\] VGND VGND VPWR VPWR alu_out_q\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10697_ clknet_leaf_83_clk _00789_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfxtp_1
XFILLER_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_2480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_2199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_112_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11318_ clknet_leaf_1_clk _01359_ VGND VGND VPWR VPWR cpuregs\[5\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_11249_ clknet_leaf_144_clk _01290_ VGND VGND VPWR VPWR cpuregs\[22\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05810_ _02047_ _02371_ _02370_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__o21a_1
X_06790_ cpuregs\[8\]\[17\] cpuregs\[9\]\[17\] cpuregs\[10\]\[17\] cpuregs\[11\]\[17\]
+ net791 net754 VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__mux4_1
XFILLER_83_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_121_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05741_ _02124_ _02309_ _02310_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__o21a_1
X_08460_ net794 cpuregs\[22\]\[31\] VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__and2b_1
XFILLER_91_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05672_ _02143_ net584 net581 _02144_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__o2bb2a_1
X_07411_ net1372 net297 net440 VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__mux2_1
X_08391_ net2261 _04139_ net996 VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__o21ai_1
XFILLER_36_799 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07342_ net1351 net312 net447 VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_15_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_50_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07273_ net1259 net320 net454 VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__mux2_1
X_09012_ cpuregs\[24\]\[29\] cpuregs\[25\]\[29\] cpuregs\[26\]\[29\] cpuregs\[27\]\[29\]
+ net973 net938 VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__mux4_1
X_06224_ reg_pc\[22\] _02664_ VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__and2_1
Xhold100 net48 VGND VGND VPWR VPWR net1208 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_145_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_130_Left_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06155_ reg_out\[9\] alu_out_q\[9\] net840 VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__mux2_1
Xhold133 cpuregs\[26\]\[29\] VGND VGND VPWR VPWR net1241 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_587 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold144 cpuregs\[1\]\[19\] VGND VGND VPWR VPWR net1252 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05106_ net705 net881 _01710_ net702 VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__a22o_1
XFILLER_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold111 cpuregs\[13\]\[3\] VGND VGND VPWR VPWR net1219 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 cpuregs\[13\]\[9\] VGND VGND VPWR VPWR net1230 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold177 cpuregs\[27\]\[25\] VGND VGND VPWR VPWR net1285 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 cpuregs\[29\]\[21\] VGND VGND VPWR VPWR net1263 sky130_fd_sc_hd__dlygate4sd3_1
X_06086_ net896 _02554_ net660 VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__a21oi_1
Xhold166 cpuregs\[25\]\[6\] VGND VGND VPWR VPWR net1274 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout624 net625 VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__buf_2
Xfanout613 _01598_ VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__clkbuf_4
X_05037_ is_lb_lh_lw_lbu_lhu _01591_ VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__and2_1
Xhold199 cpuregs\[14\]\[7\] VGND VGND VPWR VPWR net1307 sky130_fd_sc_hd__dlygate4sd3_1
X_09914_ clknet_leaf_140_clk _00043_ VGND VGND VPWR VPWR cpuregs\[11\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xfanout602 net603 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__clkbuf_4
Xhold188 cpuregs\[13\]\[5\] VGND VGND VPWR VPWR net1296 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout657 _01567_ VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_70_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09845_ net314 net1912 net346 VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__mux2_1
Xfanout635 _01570_ VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__buf_2
Xfanout646 net647 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__buf_4
Xfanout679 net681 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__clkbuf_4
Xfanout668 _01556_ VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__buf_6
X_06988_ _03396_ _03397_ _03398_ net729 net639 VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__a221o_1
XFILLER_73_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09776_ net323 net1967 net353 VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__mux2_1
XFILLER_46_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05939_ net696 net123 net206 net593 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__a22o_1
X_08727_ _04404_ _04405_ net672 VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__mux2_1
XFILLER_54_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08658_ net889 _04346_ net664 VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__a21o_1
X_07609_ net1796 net312 net414 VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__mux2_1
XFILLER_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08589_ cpuregs\[28\]\[6\] cpuregs\[29\]\[6\] cpuregs\[30\]\[6\] cpuregs\[31\]\[6\]
+ net953 net918 VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__mux4_1
X_10620_ clknet_leaf_109_clk _00744_ VGND VGND VPWR VPWR count_cycle\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_139_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10551_ clknet_leaf_89_clk _00675_ VGND VGND VPWR VPWR reg_pc\[31\] sky130_fd_sc_hd__dfxtp_1
X_10482_ clknet_leaf_83_clk _00606_ VGND VGND VPWR VPWR count_instr\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_20_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11103_ clknet_leaf_77_clk _01154_ VGND VGND VPWR VPWR cpuregs\[24\]\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_9_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11034_ clknet_leaf_72_clk _01090_ VGND VGND VPWR VPWR cpuregs\[19\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_104_782 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10818_ clknet_leaf_97_clk _00877_ VGND VGND VPWR VPWR instr_sra sky130_fd_sc_hd__dfxtp_1
XFILLER_20_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_119_2239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10749_ clknet_leaf_100_clk _00840_ VGND VGND VPWR VPWR latched_branch sky130_fd_sc_hd__dfxtp_1
XFILLER_146_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput216 net216 VGND VGND VPWR VPWR pcpi_rs2[21] sky130_fd_sc_hd__buf_2
Xoutput205 net205 VGND VGND VPWR VPWR pcpi_rs2[11] sky130_fd_sc_hd__buf_2
Xoutput227 net227 VGND VGND VPWR VPWR pcpi_rs2[31] sky130_fd_sc_hd__buf_2
XFILLER_153_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07960_ _03780_ _03781_ _03782_ VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__a21oi_1
X_06911_ net862 _03324_ net306 VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__mux2_1
XFILLER_68_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_4_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_07891_ reg_pc\[27\] net505 _03724_ net605 VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_52_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09630_ net241 net1900 net376 VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__mux2_1
X_06842_ net735 _03257_ VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__or2_1
XFILLER_56_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09561_ net1427 net252 net383 VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__mux2_1
X_06773_ reg_pc\[16\] net561 _03191_ net521 VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__a211o_1
X_08512_ cpu_state\[1\] cpu_state\[0\] net978 net810 VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__and4bb_1
X_05724_ _02135_ _02295_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__nor2_1
XFILLER_130_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09492_ net1808 net264 net391 VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__mux2_1
XFILLER_91_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08443_ net755 _04174_ _04175_ _04176_ net653 VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__o221a_1
X_05655_ _02116_ _02206_ _02234_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__o21a_2
XFILLER_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08374_ count_cycle\[40\] count_cycle\[41\] count_cycle\[42\] _04125_ VGND VGND VPWR
+ VPWR _04130_ sky130_fd_sc_hd__and4_1
X_05586_ _02164_ _02165_ VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__nand2_1
XFILLER_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07325_ net1639 net240 net452 VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__mux2_1
X_07256_ net1947 net253 net461 VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__mux2_1
X_06207_ reg_pc\[18\] _02648_ reg_pc\[19\] VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__a21oi_1
X_07187_ net2090 net248 net469 VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__mux2_1
XFILLER_117_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06138_ _02598_ _02599_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__nor2_1
XFILLER_133_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_579 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06069_ reg_sh\[3\] reg_sh\[2\] VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__nand2_1
Xfanout421 _03581_ VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__buf_4
XFILLER_132_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout432 _03577_ VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_6_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout410 net411 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkbuf_8
XFILLER_58_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout454 net455 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__clkbuf_8
Xfanout465 _03566_ VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__clkbuf_8
Xfanout443 _03573_ VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__buf_4
X_09828_ net245 net1413 net352 VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout498 _01627_ VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__buf_2
Xfanout487 _04203_ VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__clkbuf_4
XFILLER_47_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout476 net477 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__clkbuf_8
X_09759_ net257 net1881 net359 VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__mux2_1
XFILLER_46_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_500 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10603_ clknet_leaf_86_clk _00727_ VGND VGND VPWR VPWR count_cycle\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10534_ clknet_leaf_95_clk _00658_ VGND VGND VPWR VPWR reg_pc\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10465_ clknet_leaf_106_clk _00589_ VGND VGND VPWR VPWR count_instr\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_114_2158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10396_ clknet_leaf_124_clk _00520_ VGND VGND VPWR VPWR cpuregs\[20\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_145_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11017_ clknet_leaf_1_clk _01073_ VGND VGND VPWR VPWR cpuregs\[19\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_129_2390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05440_ net715 _02016_ _02017_ _02021_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__a31o_1
XFILLER_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05371_ count_cycle\[24\] net618 VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__or2_1
XFILLER_20_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07110_ net857 net511 net490 _03491_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__o211a_1
XFILLER_20_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08090_ _03896_ _03902_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__nor2_1
Xclkload20 clknet_leaf_6_clk VGND VGND VPWR VPWR clkload20/Y sky130_fd_sc_hd__clkinv_4
X_07041_ _03446_ _03447_ _03448_ _03449_ net729 net724 VGND VGND VPWR VPWR _03450_
+ sky130_fd_sc_hd__mux4_2
XFILLER_118_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload53 clknet_leaf_28_clk VGND VGND VPWR VPWR clkload53/Y sky130_fd_sc_hd__inv_6
Xclkload42 clknet_leaf_18_clk VGND VGND VPWR VPWR clkload42/Y sky130_fd_sc_hd__inv_12
Xclkload31 clknet_leaf_140_clk VGND VGND VPWR VPWR clkload31/Y sky130_fd_sc_hd__clkinv_4
Xclkload64 clknet_leaf_40_clk VGND VGND VPWR VPWR clkload64/Y sky130_fd_sc_hd__inv_8
Xclkload75 clknet_leaf_41_clk VGND VGND VPWR VPWR clkload75/Y sky130_fd_sc_hd__inv_12
XFILLER_115_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload86 clknet_leaf_120_clk VGND VGND VPWR VPWR clkload86/Y sky130_fd_sc_hd__clkinvlp_4
XTAP_TAPCELL_ROW_149_2711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload97 clknet_leaf_132_clk VGND VGND VPWR VPWR clkload97/Y sky130_fd_sc_hd__inv_12
X_08992_ cpuregs\[12\]\[28\] cpuregs\[13\]\[28\] cpuregs\[14\]\[28\] cpuregs\[15\]\[28\]
+ net972 net937 VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_149_2722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07943_ net977 _03767_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__and2_1
XFILLER_110_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07874_ _02654_ reg_next_pc\[19\] net574 VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__mux2_2
X_06825_ net525 _03224_ _03225_ _03227_ _03241_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__o41a_1
XFILLER_68_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09613_ net312 net1975 net373 VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__mux2_1
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06756_ net864 net514 VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__or2_1
X_09544_ net1636 net324 net381 VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__mux2_1
X_06687_ _03105_ _03106_ net647 VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__mux2_1
XFILLER_52_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05707_ _02171_ net583 net579 _02170_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__a22o_1
X_09475_ net1904 net341 net389 VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__mux2_1
XFILLER_34_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08426_ count_cycle\[61\] _04161_ net1001 VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__a21boi_1
X_05638_ _02077_ _02209_ _02217_ VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_65_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload3 clknet_4_4_0_clk VGND VGND VPWR VPWR clkload3/X sky130_fd_sc_hd__clkbuf_8
X_05569_ _02148_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__inv_2
X_08357_ _04119_ net980 _04118_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__and3b_1
X_07308_ net1970 net314 net451 VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__mux2_1
X_08288_ _04075_ _04076_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__nor2_1
XFILLER_109_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07239_ net1355 net325 net458 VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__mux2_1
XFILLER_4_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10250_ clknet_leaf_25_clk _00374_ VGND VGND VPWR VPWR cpuregs\[27\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_133_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10181_ clknet_leaf_12_clk _00305_ VGND VGND VPWR VPWR cpuregs\[9\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xfanout240 net242 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_2
XFILLER_120_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout262 _02684_ VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_1
Xfanout273 _02671_ VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_2
Xfanout251 net254 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_2
XFILLER_87_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout295 net298 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__clkbuf_2
Xfanout284 net286 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__clkbuf_2
XFILLER_75_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10517_ clknet_leaf_81_clk _00641_ VGND VGND VPWR VPWR count_instr\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_754 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11497_ clknet_leaf_68_clk _01535_ VGND VGND VPWR VPWR cpuregs\[10\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_143_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10448_ clknet_leaf_52_clk _00572_ VGND VGND VPWR VPWR cpuregs\[17\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10379_ clknet_leaf_22_clk _00503_ VGND VGND VPWR VPWR cpuregs\[25\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04940_ mem_do_rinst mem_do_prefetch VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_144_2641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07590_ net1201 net250 net421 VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__mux2_1
XFILLER_53_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06610_ _03027_ _03028_ net732 VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__mux2_1
XFILLER_52_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06541_ net606 _02962_ _02963_ _02967_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__a31o_1
XFILLER_45_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09260_ _01099_ _04742_ _04797_ _02515_ net2345 VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__a32o_1
X_06472_ net731 _02901_ VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__or2_1
X_08211_ _04012_ _04013_ VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__and2_1
X_05423_ count_instr\[60\] net816 net825 count_cycle\[60\] VGND VGND VPWR VPWR _02007_
+ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_47_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09191_ decoded_imm_j\[8\] _01122_ net333 VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__mux2_1
XFILLER_21_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08142_ _03941_ _03942_ _03949_ _03950_ VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__o2bb2a_1
X_05354_ count_instr\[23\] net821 net623 _01942_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_60_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload131 clknet_leaf_73_clk VGND VGND VPWR VPWR clkload131/Y sky130_fd_sc_hd__clkinv_4
XFILLER_119_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload120 clknet_leaf_63_clk VGND VGND VPWR VPWR clkload120/X sky130_fd_sc_hd__clkbuf_8
X_05285_ net714 _01873_ _01874_ _01878_ VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__a31o_1
X_08073_ _03711_ _03712_ _03864_ VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_60_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload142 clknet_leaf_76_clk VGND VGND VPWR VPWR clkload142/X sky130_fd_sc_hd__clkbuf_4
X_07024_ _03405_ _03407_ _03431_ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__nand3_1
XFILLER_130_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_103_814 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08975_ cpuregs\[28\]\[27\] cpuregs\[29\]\[27\] cpuregs\[30\]\[27\] cpuregs\[31\]\[27\]
+ net971 net936 VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__mux4_1
XFILLER_102_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold15 cpuregs\[0\]\[25\] VGND VGND VPWR VPWR net1123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net141 VGND VGND VPWR VPWR net1145 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_69_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold26 cpuregs\[0\]\[12\] VGND VGND VPWR VPWR net1134 sky130_fd_sc_hd__dlygate4sd3_1
X_07926_ _03700_ _03744_ VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__xnor2_1
Xhold59 net144 VGND VGND VPWR VPWR net1167 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 decoded_rd\[0\] VGND VGND VPWR VPWR net1156 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_67_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07857_ _02621_ reg_next_pc\[11\] net571 VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__mux2_2
XFILLER_17_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06808_ net868 net509 _03144_ net497 VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__o211a_1
X_07788_ count_instr\[46\] count_instr\[45\] _03662_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__and3_1
XFILLER_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09527_ net1421 net256 net388 VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__mux2_1
X_06739_ _03155_ _03156_ _03157_ _03158_ net726 net639 VGND VGND VPWR VPWR _03159_
+ sky130_fd_sc_hd__mux4_1
XFILLER_25_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09458_ net267 net2070 net395 VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__mux2_1
XFILLER_101_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08409_ _04151_ _04152_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__nor2_1
X_09389_ mem_rdata_q\[24\] _04794_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__and2_1
XFILLER_40_856 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11420_ clknet_leaf_4_clk _01458_ VGND VGND VPWR VPWR cpuregs\[8\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_11351_ clknet_leaf_152_clk _01389_ VGND VGND VPWR VPWR cpuregs\[6\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_125_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_95_1850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10302_ clknet_leaf_146_clk _00426_ VGND VGND VPWR VPWR cpuregs\[26\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_111_2106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11282_ clknet_leaf_149_clk _01323_ VGND VGND VPWR VPWR cpuregs\[4\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10233_ clknet_leaf_114_clk _00357_ VGND VGND VPWR VPWR cpuregs\[27\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_10164_ clknet_leaf_73_clk _00288_ VGND VGND VPWR VPWR cpuregs\[21\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout1002 net34 VGND VGND VPWR VPWR net1002 sky130_fd_sc_hd__buf_4
XFILLER_79_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10095_ clknet_leaf_46_clk _00219_ VGND VGND VPWR VPWR cpuregs\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_411 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_2079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10997_ clknet_leaf_41_clk _01053_ VGND VGND VPWR VPWR cpuregs\[18\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_122_2279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11618_ net844 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__buf_1
XFILLER_129_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold518 cpuregs\[20\]\[24\] VGND VGND VPWR VPWR net1626 sky130_fd_sc_hd__dlygate4sd3_1
Xhold507 cpuregs\[4\]\[5\] VGND VGND VPWR VPWR net1615 sky130_fd_sc_hd__dlygate4sd3_1
Xhold529 cpuregs\[28\]\[8\] VGND VGND VPWR VPWR net1637 sky130_fd_sc_hd__dlygate4sd3_1
X_05070_ reg_pc\[2\] decoded_imm\[2\] VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__nor2_1
XFILLER_112_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1207 count_instr\[16\] VGND VGND VPWR VPWR net2315 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_112_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1229 count_cycle\[61\] VGND VGND VPWR VPWR net2337 sky130_fd_sc_hd__dlygate4sd3_1
X_08760_ net901 _04443_ VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__or2_1
Xhold1218 instr_lw VGND VGND VPWR VPWR net2326 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_66_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05972_ net879 _02488_ net634 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__mux2_1
XFILLER_122_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07711_ count_instr\[18\] count_instr\[17\] _03613_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__and3_1
XFILLER_65_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04923_ net887 VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__inv_2
X_08691_ net669 _04371_ net895 VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__o21a_1
XFILLER_81_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07642_ net313 net1855 net410 VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09312_ net132 net407 _04815_ _04204_ VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__o211a_1
X_07573_ net1613 net322 net418 VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__mux2_1
XFILLER_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xpicorv32_1103 VGND VGND VPWR VPWR picorv32_1103/HI trace_data[31] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_62_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06524_ _02943_ _02944_ net645 VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__mux2_1
XFILLER_139_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09243_ net1320 net295 net405 VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__mux2_1
XFILLER_22_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06455_ net197 net506 VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__or2_1
XFILLER_147_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05406_ count_instr\[59\] net816 net825 count_cycle\[59\] VGND VGND VPWR VPWR _01991_
+ sky130_fd_sc_hd__a22o_1
X_09174_ net826 net549 _04786_ _04787_ VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__a22o_1
X_06386_ net649 _02817_ net723 VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__a21o_1
X_05337_ _01902_ _01913_ _01914_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__o21ai_1
X_08125_ _03932_ _03933_ net685 VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__a21o_1
XFILLER_21_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_224 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05268_ _01855_ _01857_ _01858_ _01861_ _01863_ VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__a41oi_1
X_08056_ _03846_ _03859_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__nand2_1
Xoutput49 net49 VGND VGND VPWR VPWR mem_addr[24] sky130_fd_sc_hd__buf_2
XFILLER_150_739 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07007_ cpuregs\[4\]\[25\] cpuregs\[5\]\[25\] cpuregs\[6\]\[25\] cpuregs\[7\]\[25\]
+ net808 net771 VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__mux4_1
XFILLER_134_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput38 net38 VGND VGND VPWR VPWR mem_addr[13] sky130_fd_sc_hd__buf_2
X_05199_ net711 _01793_ _01794_ _01799_ VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__a31o_1
XFILLER_1_716 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_73_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08958_ net902 _04630_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__or2_1
XFILLER_103_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08889_ cpuregs\[16\]\[22\] cpuregs\[17\]\[22\] cpuregs\[18\]\[22\] cpuregs\[19\]\[22\]
+ net964 net929 VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__mux4_1
X_07909_ net848 _03697_ VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__or2_1
X_10920_ clknet_leaf_32_clk _00976_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_16_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10851_ clknet_leaf_117_clk _00910_ VGND VGND VPWR VPWR decoded_imm_j\[3\] sky130_fd_sc_hd__dfxtp_1
X_10782_ clknet_leaf_90_clk alu_out\[29\] VGND VGND VPWR VPWR alu_out_q\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11403_ clknet_leaf_70_clk _01441_ VGND VGND VPWR VPWR cpuregs\[7\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_11334_ clknet_leaf_69_clk _01375_ VGND VGND VPWR VPWR cpuregs\[5\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11265_ clknet_leaf_33_clk _01306_ VGND VGND VPWR VPWR cpuregs\[22\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10216_ clknet_leaf_55_clk _00340_ VGND VGND VPWR VPWR cpuregs\[14\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11196_ clknet_leaf_17_clk _01237_ VGND VGND VPWR VPWR cpuregs\[29\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10147_ clknet_leaf_1_clk _00271_ VGND VGND VPWR VPWR cpuregs\[21\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_2319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10078_ clknet_leaf_146_clk _00202_ VGND VGND VPWR VPWR cpuregs\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_44_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_139_2562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06240_ reg_pc\[25\] _02677_ VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__and2_1
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06171_ net320 net1726 net476 VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__mux2_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_152_2762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold315 cpuregs\[15\]\[23\] VGND VGND VPWR VPWR net1423 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold326 cpuregs\[17\]\[7\] VGND VGND VPWR VPWR net1434 sky130_fd_sc_hd__dlygate4sd3_1
Xhold304 cpuregs\[2\]\[4\] VGND VGND VPWR VPWR net1412 sky130_fd_sc_hd__dlygate4sd3_1
X_05122_ _01727_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__inv_2
Xhold337 cpuregs\[4\]\[22\] VGND VGND VPWR VPWR net1445 sky130_fd_sc_hd__dlygate4sd3_1
X_09930_ clknet_leaf_42_clk _00059_ VGND VGND VPWR VPWR cpuregs\[11\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_132_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold359 cpuregs\[31\]\[14\] VGND VGND VPWR VPWR net1467 sky130_fd_sc_hd__dlygate4sd3_1
Xhold348 cpuregs\[29\]\[15\] VGND VGND VPWR VPWR net1456 sky130_fd_sc_hd__dlygate4sd3_1
X_05053_ count_instr\[0\] net820 count_cycle\[32\] net824 VGND VGND VPWR VPWR _01665_
+ sky130_fd_sc_hd__a22o_1
Xfanout806 net808 VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09861_ net245 net2221 net348 VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__mux2_1
Xfanout817 net818 VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__clkbuf_4
Xfanout839 instr_jal VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__buf_2
Xfanout828 net831 VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__clkbuf_4
X_09792_ net257 net2200 net355 VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__mux2_1
Xhold1015 cpuregs\[3\]\[27\] VGND VGND VPWR VPWR net2123 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_112_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08812_ cpuregs\[24\]\[18\] cpuregs\[25\]\[18\] cpuregs\[26\]\[18\] cpuregs\[27\]\[18\]
+ net960 net925 VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__mux4_1
Xhold1004 cpuregs\[16\]\[17\] VGND VGND VPWR VPWR net2112 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_669 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08743_ net677 _04427_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__or2_1
X_05955_ net220 net595 _02476_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__a21o_1
Xhold1037 cpuregs\[11\]\[12\] VGND VGND VPWR VPWR net2145 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1048 cpuregs\[22\]\[10\] VGND VGND VPWR VPWR net2156 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1026 cpuregs\[22\]\[7\] VGND VGND VPWR VPWR net2134 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1059 is_alu_reg_imm VGND VGND VPWR VPWR net2167 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05886_ _02106_ _02438_ _02439_ VGND VGND VPWR VPWR alu_out\[26\] sky130_fd_sc_hd__o21ai_1
XFILLER_93_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08674_ _04352_ _04361_ _04362_ net659 net895 VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__a221o_1
XFILLER_54_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07625_ net1487 net243 net416 VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__mux2_1
XFILLER_54_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_907 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07556_ net252 net2098 net424 VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__mux2_1
XFILLER_139_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06507_ decoded_imm\[7\] net878 VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__nand2_1
X_07487_ net1959 net261 net433 VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__mux2_1
X_09226_ _03560_ _03567_ VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__nor2_4
XFILLER_148_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06438_ _02832_ _02834_ _02867_ net609 VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__a31o_1
XFILLER_147_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09157_ net2311 net501 _04755_ _04773_ VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__a22o_1
XFILLER_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06369_ net723 _02801_ _02798_ net727 VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__o211a_1
XFILLER_147_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08108_ decoded_imm_j\[19\] _03716_ VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__and2_1
X_09088_ _04739_ _01099_ _04742_ _02515_ net1661 VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__a32o_1
XFILLER_150_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_75_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08039_ net558 _03855_ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold871 cpuregs\[6\]\[22\] VGND VGND VPWR VPWR net1979 sky130_fd_sc_hd__dlygate4sd3_1
Xhold882 cpuregs\[3\]\[14\] VGND VGND VPWR VPWR net1990 sky130_fd_sc_hd__dlygate4sd3_1
Xhold860 cpuregs\[28\]\[17\] VGND VGND VPWR VPWR net1968 sky130_fd_sc_hd__dlygate4sd3_1
Xhold893 cpuregs\[11\]\[28\] VGND VGND VPWR VPWR net2001 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_107_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11050_ clknet_leaf_101_clk _01101_ VGND VGND VPWR VPWR mem_rdata_q\[7\] sky130_fd_sc_hd__dfxtp_1
X_10001_ clknet_leaf_68_clk _00125_ VGND VGND VPWR VPWR cpuregs\[12\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_130_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_2027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_829 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_4_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10903_ clknet_leaf_147_clk _00959_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dfxtp_1
XFILLER_44_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10834_ clknet_leaf_96_clk _00893_ VGND VGND VPWR VPWR decoded_imm_j\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_60_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10765_ clknet_leaf_134_clk alu_out\[12\] VGND VGND VPWR VPWR alu_out_q\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10696_ clknet_leaf_84_clk _00788_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_23_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_134_2470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_134_2481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11317_ clknet_leaf_2_clk _01358_ VGND VGND VPWR VPWR cpuregs\[5\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_11248_ clknet_leaf_123_clk _01289_ VGND VGND VPWR VPWR cpuregs\[22\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_11179_ clknet_leaf_73_clk _01220_ VGND VGND VPWR VPWR cpuregs\[23\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_67_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05740_ _02124_ _02309_ net543 VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__a21oi_1
XFILLER_91_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05671_ net888 net847 net579 _02250_ VGND VGND VPWR VPWR alu_out\[0\] sky130_fd_sc_hd__a31o_1
X_08390_ count_cycle\[46\] count_cycle\[47\] count_cycle\[48\] _04135_ VGND VGND VPWR
+ VPWR _04140_ sky130_fd_sc_hd__and4_1
X_07410_ net1805 net302 net439 VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__mux2_1
XFILLER_51_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07341_ net1616 net317 net446 VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__mux2_1
XFILLER_51_759 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_149_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07272_ net1411 net323 net454 VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__mux2_1
XFILLER_129_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09011_ cpuregs\[28\]\[29\] cpuregs\[29\]\[29\] cpuregs\[30\]\[29\] cpuregs\[31\]\[29\]
+ net974 net939 VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__mux4_1
X_06223_ reg_pc\[22\] _02664_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__nor2_1
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold101 cpuregs\[12\]\[30\] VGND VGND VPWR VPWR net1209 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_544 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06154_ net338 net2191 net476 VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__mux2_1
XFILLER_145_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold112 cpuregs\[26\]\[28\] VGND VGND VPWR VPWR net1220 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold123 cpuregs\[31\]\[3\] VGND VGND VPWR VPWR net1231 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 cpuregs\[29\]\[7\] VGND VGND VPWR VPWR net1242 sky130_fd_sc_hd__dlygate4sd3_1
X_05105_ count_cycle\[4\] net617 net589 _01712_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__o211a_1
Xhold156 cpuregs\[2\]\[29\] VGND VGND VPWR VPWR net1264 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold145 cpuregs\[24\]\[31\] VGND VGND VPWR VPWR net1253 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold167 cpuregs\[21\]\[10\] VGND VGND VPWR VPWR net1275 sky130_fd_sc_hd__dlygate4sd3_1
X_06085_ _02552_ _02553_ net674 VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__mux2_1
XFILLER_104_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout614 _01598_ VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__buf_2
X_05036_ _01636_ _01642_ _01650_ _01649_ VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__a31o_1
Xhold189 cpuregs\[4\]\[12\] VGND VGND VPWR VPWR net1297 sky130_fd_sc_hd__dlygate4sd3_1
X_09913_ clknet_leaf_139_clk _00042_ VGND VGND VPWR VPWR cpuregs\[11\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold178 cpuregs\[25\]\[8\] VGND VGND VPWR VPWR net1286 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout603 _01618_ VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout636 net637 VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__buf_4
Xfanout625 _01575_ VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_70_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09844_ net318 net1883 net346 VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__mux2_1
Xfanout647 net648 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__buf_4
Xfanout658 net659 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__buf_4
XFILLER_85_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout669 net671 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__clkbuf_4
X_06987_ _03390_ _03391_ net656 VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__mux2_1
XFILLER_58_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09775_ net326 net1560 net353 VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__mux2_1
XFILLER_27_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05938_ net696 net123 net206 net694 VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__a22o_1
X_08726_ net672 _04406_ net659 VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_1_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05869_ _02089_ net582 _02424_ _02090_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__o22a_1
XFILLER_54_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08657_ net899 _04342_ _04341_ net658 VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__o211a_1
XFILLER_81_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07608_ net1530 net317 net414 VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__mux2_1
XFILLER_54_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08588_ net899 _04280_ VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__or2_1
XFILLER_26_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07539_ net324 net2094 net422 VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__mux2_1
X_10550_ clknet_leaf_90_clk _00674_ VGND VGND VPWR VPWR reg_pc\[30\] sky130_fd_sc_hd__dfxtp_1
X_10481_ clknet_leaf_83_clk _00605_ VGND VGND VPWR VPWR count_instr\[24\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_20_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09209_ net1324 net3 net612 VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__mux2_1
XFILLER_108_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11102_ clknet_leaf_73_clk _01153_ VGND VGND VPWR VPWR cpuregs\[24\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_9_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold690 cpuregs\[24\]\[2\] VGND VGND VPWR VPWR net1798 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11033_ clknet_leaf_67_clk _01089_ VGND VGND VPWR VPWR cpuregs\[19\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_89_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_794 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_134_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_862 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10817_ clknet_leaf_97_clk _00876_ VGND VGND VPWR VPWR instr_srl sky130_fd_sc_hd__dfxtp_1
XFILLER_60_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_136_2510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10748_ clknet_leaf_111_clk _00839_ VGND VGND VPWR VPWR latched_stalu sky130_fd_sc_hd__dfxtp_1
XFILLER_145_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10679_ clknet_leaf_89_clk _04905_ VGND VGND VPWR VPWR reg_out\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput217 net217 VGND VGND VPWR VPWR pcpi_rs2[22] sky130_fd_sc_hd__buf_2
Xoutput206 net206 VGND VGND VPWR VPWR pcpi_rs2[12] sky130_fd_sc_hd__buf_2
XFILLER_127_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput228 net228 VGND VGND VPWR VPWR pcpi_rs2[3] sky130_fd_sc_hd__buf_2
XFILLER_153_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06910_ net524 _03305_ _03306_ _03308_ _03323_ VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__o41a_1
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07890_ _02688_ reg_next_pc\[27\] net575 VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__mux2_2
XFILLER_67_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06841_ cpuregs\[16\]\[19\] cpuregs\[17\]\[19\] cpuregs\[18\]\[19\] cpuregs\[19\]\[19\]
+ net795 net758 VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__mux4_1
XFILLER_68_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09560_ net2008 net255 net383 VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__mux2_1
X_06772_ net724 _03190_ _03189_ net518 VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__o211a_1
XFILLER_49_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09491_ net1862 net269 net391 VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__mux2_1
XFILLER_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08511_ net977 _01601_ _04212_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__and3_1
X_05723_ _02193_ _02294_ net692 VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__mux2_1
XFILLER_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08442_ cpuregs\[11\]\[31\] net799 net761 VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__a21bo_1
XFILLER_63_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05654_ _02109_ _02221_ _02223_ _02233_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__o211a_1
X_08373_ _04129_ net985 _04128_ VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__and3b_1
X_05585_ net879 net125 VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__or2_1
X_07324_ net1277 net244 net452 VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__mux2_1
X_07255_ net1537 net258 net460 VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__mux2_1
XFILLER_139_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06206_ reg_out\[19\] alu_out_q\[19\] net842 VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__mux2_1
X_07186_ net1822 net254 net469 VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__mux2_1
XFILLER_105_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06137_ reg_pc\[5\] _02593_ VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__and2_1
X_06068_ reg_sh\[2\] _02517_ _02537_ _01554_ VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_133_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05019_ net687 net848 net603 VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_6_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout400 _04865_ VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__buf_4
Xfanout411 _03584_ VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__buf_4
Xfanout422 net425 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__buf_4
XFILLER_120_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout433 _03577_ VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__clkbuf_4
Xfanout444 _03573_ VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__clkbuf_8
Xfanout455 _03569_ VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__clkbuf_4
Xfanout466 net467 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__clkbuf_8
X_09827_ net248 net2212 net352 VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__mux2_1
XFILLER_104_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout499 net501 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__buf_2
XFILLER_59_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout488 net491 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__buf_2
Xfanout477 _02581_ VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__buf_4
X_09758_ net261 net1825 net360 VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_87_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08709_ _04385_ _04394_ _04395_ net660 net896 VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__a221o_1
X_09689_ net1445 net272 net367 VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__mux2_1
XFILLER_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10602_ clknet_leaf_86_clk _00726_ VGND VGND VPWR VPWR count_cycle\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_80_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10533_ clknet_leaf_134_clk _00657_ VGND VGND VPWR VPWR reg_pc\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_2148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10464_ clknet_leaf_107_clk _00588_ VGND VGND VPWR VPWR count_instr\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_2159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10395_ clknet_leaf_122_clk _00519_ VGND VGND VPWR VPWR cpuregs\[20\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_8_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11016_ clknet_leaf_13_clk _01072_ VGND VGND VPWR VPWR cpuregs\[19\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_129_2391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05370_ count_instr\[24\] net822 net623 _01957_ VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__a211o_1
XFILLER_20_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload10 clknet_4_12_0_clk VGND VGND VPWR VPWR clkload10/Y sky130_fd_sc_hd__inv_8
X_07040_ _03440_ _03441_ net656 VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__mux2_1
Xclkload43 clknet_leaf_19_clk VGND VGND VPWR VPWR clkload43/Y sky130_fd_sc_hd__clkinv_8
Xclkload21 clknet_leaf_7_clk VGND VGND VPWR VPWR clkload21/Y sky130_fd_sc_hd__clkinv_4
Xclkload32 clknet_leaf_141_clk VGND VGND VPWR VPWR clkload32/Y sky130_fd_sc_hd__inv_6
Xclkload65 clknet_leaf_42_clk VGND VGND VPWR VPWR clkload65/Y sky130_fd_sc_hd__clkinv_8
Xclkload76 clknet_leaf_44_clk VGND VGND VPWR VPWR clkload76/Y sky130_fd_sc_hd__bufinv_16
Xclkload54 clknet_leaf_29_clk VGND VGND VPWR VPWR clkload54/Y sky130_fd_sc_hd__inv_6
Xclkload87 clknet_leaf_121_clk VGND VGND VPWR VPWR clkload87/Y sky130_fd_sc_hd__bufinv_16
XFILLER_114_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload98 clknet_leaf_133_clk VGND VGND VPWR VPWR clkload98/Y sky130_fd_sc_hd__inv_12
XTAP_TAPCELL_ROW_149_2723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08991_ net222 net633 _04661_ _04662_ VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__o22a_1
XFILLER_115_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_910 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07942_ net559 _03765_ _03766_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__a21o_1
X_07873_ reg_pc\[18\] net504 _03714_ net604 VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__a22o_1
X_06824_ reg_pc\[18\] net562 _03240_ net518 net521 VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__a221o_1
X_09612_ net316 net1634 net373 VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__mux2_1
X_09543_ net1224 net327 net381 VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__mux2_1
X_06755_ net868 net513 _03173_ net497 VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__o211a_1
XFILLER_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06686_ cpuregs\[16\]\[13\] cpuregs\[17\]\[13\] cpuregs\[18\]\[13\] cpuregs\[19\]\[13\]
+ net780 net744 VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__mux4_1
XFILLER_51_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05706_ _02172_ net578 VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__nor2_1
X_09474_ net1508 _02604_ net389 VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__mux2_1
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08425_ _04161_ _04162_ VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__nor2_1
X_05637_ _02072_ _02216_ _02215_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_65_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08356_ count_cycle\[34\] count_cycle\[35\] _04115_ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__and3_1
Xclkload4 clknet_4_5_0_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__inv_6
X_05568_ _02146_ _02147_ VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__and2b_2
X_07307_ net1554 net319 net450 VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__mux2_1
X_05499_ net853 net224 VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__and2_1
X_08287_ net2263 _04074_ net985 VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__o21ai_1
X_07238_ net1230 net328 net458 VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__mux2_1
X_07169_ net2153 net325 net466 VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__mux2_1
XFILLER_1_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10180_ clknet_leaf_4_clk _00304_ VGND VGND VPWR VPWR cpuregs\[9\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout241 net242 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_2
Xfanout274 _02671_ VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__clkbuf_1
Xfanout252 net254 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout263 net264 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_2
Xfanout296 net298 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_1
XFILLER_115_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout285 net286 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__clkbuf_2
XFILLER_75_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11496_ clknet_leaf_53_clk _01534_ VGND VGND VPWR VPWR cpuregs\[10\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_10516_ clknet_leaf_81_clk _00640_ VGND VGND VPWR VPWR count_instr\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10447_ clknet_leaf_46_clk _00571_ VGND VGND VPWR VPWR cpuregs\[17\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10378_ clknet_leaf_24_clk _00502_ VGND VGND VPWR VPWR cpuregs\[25\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_144_2631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_144_2642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06540_ net495 _02883_ _02965_ _02966_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__a31o_1
X_06471_ cpuregs\[8\]\[5\] cpuregs\[9\]\[5\] cpuregs\[10\]\[5\] cpuregs\[11\]\[5\]
+ net776 net740 VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__mux4_1
X_08210_ net814 _03724_ VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__or2_1
X_05422_ net21 net596 net588 VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_47_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09190_ mem_rdata_q\[28\] net21 net613 VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__mux2_1
XFILLER_60_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08141_ _03943_ _03948_ net837 VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__o21ai_1
X_05353_ count_instr\[55\] net816 net825 count_cycle\[55\] VGND VGND VPWR VPWR _01942_
+ sky130_fd_sc_hd__a22o_1
XFILLER_119_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05284_ net704 net344 _01875_ net709 net869 VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__a32o_1
Xclkload121 clknet_leaf_93_clk VGND VGND VPWR VPWR clkload121/Y sky130_fd_sc_hd__clkinv_2
X_08072_ _03884_ _03885_ VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__xnor2_1
Xclkload110 clknet_leaf_102_clk VGND VGND VPWR VPWR clkload110/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_60_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload143 clknet_leaf_77_clk VGND VGND VPWR VPWR clkload143/Y sky130_fd_sc_hd__inv_6
Xclkload132 clknet_leaf_74_clk VGND VGND VPWR VPWR clkload132/X sky130_fd_sc_hd__clkbuf_8
XFILLER_106_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07023_ _03405_ _03407_ _03431_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__a21o_1
XFILLER_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_826 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08974_ cpuregs\[16\]\[27\] cpuregs\[17\]\[27\] cpuregs\[18\]\[27\] cpuregs\[19\]\[27\]
+ net970 net935 VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__mux4_1
XFILLER_130_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold27 cpuregs\[0\]\[20\] VGND VGND VPWR VPWR net1135 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 net142 VGND VGND VPWR VPWR net1146 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_102_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07925_ _03748_ _03749_ _03747_ VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__a21boi_1
Xhold16 cpuregs\[0\]\[0\] VGND VGND VPWR VPWR net1124 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_56_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold49 net138 VGND VGND VPWR VPWR net1157 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07856_ reg_pc\[10\] net502 _03706_ net602 VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__a22o_1
X_06807_ _03220_ _03222_ _03223_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__o21a_1
X_04999_ net838 net615 VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__or2_1
X_07787_ count_instr\[45\] _03662_ count_instr\[46\] VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__a21o_1
XFILLER_71_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09526_ net1234 net260 net388 VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__mux2_1
X_06738_ _03151_ _03152_ net648 VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__mux2_1
XFILLER_25_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09457_ net271 net2077 net394 VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08408_ net2270 _04150_ net998 VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__o21ai_1
X_06669_ decoded_imm\[13\] net873 VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__nor2_1
XFILLER_51_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_35_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09388_ decoded_imm\[5\] net552 _04856_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__o21a_1
XFILLER_137_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08339_ count_cycle\[28\] _04105_ count_cycle\[29\] VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__a21o_1
X_11350_ clknet_leaf_146_clk _01388_ VGND VGND VPWR VPWR cpuregs\[6\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_89_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10301_ clknet_leaf_140_clk _00425_ VGND VGND VPWR VPWR cpuregs\[26\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_111_2107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11281_ clknet_leaf_126_clk _01322_ VGND VGND VPWR VPWR cpuregs\[4\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10232_ clknet_leaf_138_clk _00356_ VGND VGND VPWR VPWR cpuregs\[27\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_10163_ clknet_leaf_66_clk _00287_ VGND VGND VPWR VPWR cpuregs\[21\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10094_ clknet_leaf_40_clk _00218_ VGND VGND VPWR VPWR cpuregs\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_423 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_98_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10996_ clknet_leaf_39_clk _01052_ VGND VGND VPWR VPWR cpuregs\[18\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_104_1991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11617_ net125 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__clkbuf_1
XFILLER_7_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold508 cpuregs\[21\]\[12\] VGND VGND VPWR VPWR net1616 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold519 cpuregs\[25\]\[1\] VGND VGND VPWR VPWR net1627 sky130_fd_sc_hd__dlygate4sd3_1
X_11479_ clknet_leaf_150_clk _01517_ VGND VGND VPWR VPWR cpuregs\[10\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold1208 count_instr\[53\] VGND VGND VPWR VPWR net2316 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_85_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07710_ count_instr\[17\] _03613_ count_instr\[18\] VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__a21o_1
X_05971_ reg_out\[6\] reg_next_pc\[6\] net570 VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__mux2_1
XFILLER_38_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold1219 count_cycle\[3\] VGND VGND VPWR VPWR net2327 sky130_fd_sc_hd__dlygate4sd3_1
X_04922_ net838 VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__inv_2
X_08690_ _04376_ _04377_ net671 VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__mux2_1
XFILLER_93_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_49_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07641_ net317 net1628 net410 VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__mux2_1
XFILLER_38_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07572_ net1781 net325 net418 VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__mux2_1
XFILLER_25_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09311_ net2351 net487 VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__or2_1
X_06523_ _02947_ _02948_ net645 VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1104 VGND VGND VPWR VPWR picorv32_1104/HI trace_data[32] sky130_fd_sc_hd__conb_1
XFILLER_80_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09242_ net1257 net299 net403 VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06454_ net886 net506 net488 _02883_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__o211a_1
X_05405_ net20 net597 net587 VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__a21o_1
X_09173_ mem_rdata_q\[26\] _04778_ _04779_ mem_rdata_q\[27\] VGND VGND VPWR VPWR _04787_
+ sky130_fd_sc_hd__and4b_1
X_06385_ cpuregs\[8\]\[3\] cpuregs\[9\]\[3\] cpuregs\[10\]\[3\] cpuregs\[11\]\[3\]
+ net785 net750 VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__mux4_1
XFILLER_119_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05336_ _01924_ _01925_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__nand2_1
X_08124_ _03932_ _03933_ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__nor2_1
XFILLER_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05267_ net714 _01862_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__nand2_1
X_08055_ decoded_imm_j\[15\] _03711_ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__xor2_2
Xoutput39 net39 VGND VGND VPWR VPWR mem_addr[14] sky130_fd_sc_hd__buf_2
X_07006_ cpuregs\[8\]\[25\] cpuregs\[9\]\[25\] cpuregs\[10\]\[25\] cpuregs\[11\]\[25\]
+ net804 net767 VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_77_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05198_ net710 net173 net589 _01798_ _01796_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_90_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08957_ cpuregs\[16\]\[26\] cpuregs\[17\]\[26\] cpuregs\[18\]\[26\] cpuregs\[19\]\[26\]
+ net966 net931 VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__mux4_1
X_08888_ cpuregs\[20\]\[22\] cpuregs\[21\]\[22\] cpuregs\[22\]\[22\] cpuregs\[23\]\[22\]
+ net964 net929 VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__mux4_1
XFILLER_69_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07908_ net687 _03735_ _03732_ VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__o21ai_1
X_07839_ net690 net1001 VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__and2_2
XFILLER_57_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10850_ clknet_leaf_118_clk _00909_ VGND VGND VPWR VPWR decoded_imm_j\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10781_ clknet_leaf_90_clk alu_out\[28\] VGND VGND VPWR VPWR alu_out_q\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_52_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09509_ net1431 net337 net385 VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11402_ clknet_leaf_47_clk _01440_ VGND VGND VPWR VPWR cpuregs\[7\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_138_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_90 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11333_ clknet_leaf_52_clk _01374_ VGND VGND VPWR VPWR cpuregs\[5\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11264_ clknet_leaf_23_clk _01305_ VGND VGND VPWR VPWR cpuregs\[22\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_21_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10215_ clknet_leaf_21_clk _00339_ VGND VGND VPWR VPWR cpuregs\[14\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11195_ clknet_leaf_26_clk _01236_ VGND VGND VPWR VPWR cpuregs\[29\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_10146_ clknet_leaf_13_clk _00270_ VGND VGND VPWR VPWR cpuregs\[21\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_124_2309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10077_ clknet_leaf_149_clk _00201_ VGND VGND VPWR VPWR cpuregs\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_75_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10979_ clknet_leaf_149_clk _01035_ VGND VGND VPWR VPWR cpuregs\[18\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06170_ _02621_ _02625_ net565 VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__mux2_2
XFILLER_8_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_152_2763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold305 cpuregs\[8\]\[29\] VGND VGND VPWR VPWR net1413 sky130_fd_sc_hd__dlygate4sd3_1
Xhold316 cpuregs\[4\]\[9\] VGND VGND VPWR VPWR net1424 sky130_fd_sc_hd__dlygate4sd3_1
X_05121_ reg_pc\[6\] decoded_imm\[6\] VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__nand2_1
Xhold349 cpuregs\[25\]\[31\] VGND VGND VPWR VPWR net1457 sky130_fd_sc_hd__dlygate4sd3_1
X_05052_ net700 _01660_ _01663_ VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__a21o_1
Xhold338 cpuregs\[28\]\[2\] VGND VGND VPWR VPWR net1446 sky130_fd_sc_hd__dlygate4sd3_1
Xhold327 cpuregs\[3\]\[8\] VGND VGND VPWR VPWR net1435 sky130_fd_sc_hd__dlygate4sd3_1
X_09860_ net247 net1880 net348 VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__mux2_1
Xfanout807 net808 VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__buf_4
XFILLER_140_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout818 instr_rdinstrh VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__clkbuf_4
Xfanout829 net830 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__clkbuf_4
X_09791_ net261 net1697 net356 VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__mux2_1
X_08811_ cpuregs\[28\]\[18\] cpuregs\[29\]\[18\] cpuregs\[30\]\[18\] cpuregs\[31\]\[18\]
+ net960 net925 VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__mux4_1
Xhold1005 cpuregs\[5\]\[31\] VGND VGND VPWR VPWR net2113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1049 cpuregs\[7\]\[18\] VGND VGND VPWR VPWR net2157 sky130_fd_sc_hd__dlygate4sd3_1
X_05954_ net219 net594 _02475_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__a21o_2
XFILLER_100_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1016 cpuregs\[8\]\[18\] VGND VGND VPWR VPWR net2124 sky130_fd_sc_hd__dlygate4sd3_1
X_08742_ cpuregs\[12\]\[14\] cpuregs\[13\]\[14\] cpuregs\[14\]\[14\] cpuregs\[15\]\[14\]
+ net958 net923 VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__mux4_1
Xhold1027 cpuregs\[18\]\[13\] VGND VGND VPWR VPWR net2135 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1038 cpuregs\[6\]\[11\] VGND VGND VPWR VPWR net2146 sky130_fd_sc_hd__dlygate4sd3_1
X_08673_ _04356_ _04357_ net672 VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__mux2_1
X_07624_ net1830 net249 net416 VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__mux2_1
X_05885_ _02105_ net580 net542 _02437_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_54_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07555_ net255 net2092 net424 VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__mux2_1
X_07486_ net1358 net266 net433 VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__mux2_1
X_06506_ decoded_imm\[7\] net878 VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__nor2_1
XFILLER_139_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09225_ net2366 net989 _02515_ _04744_ _04797_ VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__a32o_1
XFILLER_10_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06437_ _02832_ _02834_ _02867_ VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__a21o_1
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09156_ net2344 net499 _04754_ _04773_ VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__a22o_1
X_06368_ _02799_ _02800_ net649 VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__mux2_1
XFILLER_135_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08107_ _03917_ _03918_ net991 VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__o21a_1
X_05319_ net590 _01909_ _01910_ net183 net708 VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__a32o_1
X_06299_ instr_sra instr_srai VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__or2_1
X_09087_ _01100_ _01098_ net332 VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__and3b_1
Xclkbuf_leaf_110_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_110_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_92_1810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08038_ _03844_ _03854_ net833 VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__mux2_1
Xhold850 cpuregs\[1\]\[20\] VGND VGND VPWR VPWR net1958 sky130_fd_sc_hd__dlygate4sd3_1
Xhold861 cpuregs\[12\]\[31\] VGND VGND VPWR VPWR net1969 sky130_fd_sc_hd__dlygate4sd3_1
Xhold872 cpuregs\[14\]\[12\] VGND VGND VPWR VPWR net1980 sky130_fd_sc_hd__dlygate4sd3_1
Xhold894 cpuregs\[3\]\[23\] VGND VGND VPWR VPWR net2002 sky130_fd_sc_hd__dlygate4sd3_1
X_10000_ clknet_leaf_51_clk _00124_ VGND VGND VPWR VPWR cpuregs\[12\]\[24\] sky130_fd_sc_hd__dfxtp_1
Xhold883 cpuregs\[6\]\[24\] VGND VGND VPWR VPWR net1991 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09989_ clknet_leaf_11_clk _00113_ VGND VGND VPWR VPWR cpuregs\[12\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_106_2028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10902_ clknet_leaf_147_clk _00958_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dfxtp_1
XFILLER_44_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10833_ clknet_leaf_93_clk _00892_ VGND VGND VPWR VPWR decoded_imm_j\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_72_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10764_ clknet_leaf_134_clk alu_out\[11\] VGND VGND VPWR VPWR alu_out_q\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10695_ clknet_leaf_68_clk _00787_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_23_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_101_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_101_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_134_2482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11316_ clknet_leaf_148_clk _01357_ VGND VGND VPWR VPWR cpuregs\[5\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11247_ clknet_leaf_120_clk _01288_ VGND VGND VPWR VPWR cpuregs\[22\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_11178_ clknet_leaf_72_clk _01219_ VGND VGND VPWR VPWR cpuregs\[23\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_10129_ clknet_leaf_64_clk _00253_ VGND VGND VPWR VPWR cpuregs\[28\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_94_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05670_ is_compare _02241_ net584 _02130_ _02249_ VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__a221o_1
XFILLER_36_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07340_ net1279 net321 net446 VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_35_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09010_ net904 _04679_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__or2_1
X_07271_ net1284 net326 net454 VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__mux2_1
X_06222_ reg_out\[22\] alu_out_q\[22\] net842 VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__mux2_1
XFILLER_145_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06153_ _02610_ _02611_ net565 VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__mux2_1
XFILLER_145_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold124 cpuregs\[13\]\[30\] VGND VGND VPWR VPWR net1232 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05104_ count_instr\[4\] net819 net622 _01711_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__a211o_1
Xhold102 net35 VGND VGND VPWR VPWR net1210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 cpuregs\[15\]\[6\] VGND VGND VPWR VPWR net1243 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 cpuregs\[25\]\[4\] VGND VGND VPWR VPWR net1221 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_57_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold146 cpuregs\[21\]\[7\] VGND VGND VPWR VPWR net1254 sky130_fd_sc_hd__dlygate4sd3_1
X_06084_ cpuregs\[24\]\[3\] cpuregs\[25\]\[3\] cpuregs\[26\]\[3\] cpuregs\[27\]\[3\]
+ net954 net919 VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__mux4_1
Xhold157 cpuregs\[15\]\[9\] VGND VGND VPWR VPWR net1265 sky130_fd_sc_hd__dlygate4sd3_1
Xhold168 decoded_rd\[4\] VGND VGND VPWR VPWR net1276 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_44_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout604 net605 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__clkbuf_4
Xhold179 cpuregs\[25\]\[19\] VGND VGND VPWR VPWR net1287 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout615 net616 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__buf_2
XFILLER_59_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05035_ is_sb_sh_sw net601 VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__and2_1
X_09912_ clknet_leaf_142_clk _00041_ VGND VGND VPWR VPWR cpuregs\[11\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xfanout637 _01570_ VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09843_ net320 net2100 net345 VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__mux2_1
Xfanout626 net629 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__clkbuf_4
Xfanout648 _01567_ VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_70_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout659 net660 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__buf_4
X_06986_ net656 _03394_ net642 VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__o21a_1
X_09774_ net335 net1650 net353 VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__mux2_1
X_05937_ net696 net122 net205 net593 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__a22o_1
X_08725_ cpuregs\[8\]\[13\] cpuregs\[9\]\[13\] cpuregs\[10\]\[13\] cpuregs\[11\]\[13\]
+ net949 net914 VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__mux4_1
XFILLER_54_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05868_ _02089_ _02246_ net586 VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_1_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08656_ _04336_ _04337_ net669 VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__mux2_1
XFILLER_82_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08587_ cpuregs\[16\]\[6\] cpuregs\[17\]\[6\] cpuregs\[18\]\[6\] cpuregs\[19\]\[6\]
+ net945 net910 VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__mux4_1
X_07607_ net1593 net321 net414 VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__mux2_1
X_05799_ _02247_ _02359_ _02360_ _02362_ VGND VGND VPWR VPWR alu_out\[16\] sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_85_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07538_ net327 net1771 net422 VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__mux2_1
XFILLER_50_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07469_ net1288 net340 net430 VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__mux2_1
XFILLER_139_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10480_ clknet_leaf_86_clk _00604_ VGND VGND VPWR VPWR count_instr\[23\] sky130_fd_sc_hd__dfxtp_1
X_09208_ net1250 _01104_ net330 VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__mux2_1
X_09139_ net2283 net500 _04757_ _04767_ VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__a22o_1
XFILLER_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11101_ clknet_leaf_50_clk _01152_ VGND VGND VPWR VPWR cpuregs\[24\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_116_2190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold680 cpuregs\[4\]\[26\] VGND VGND VPWR VPWR net1788 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11032_ clknet_leaf_48_clk _01088_ VGND VGND VPWR VPWR cpuregs\[19\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold691 cpuregs\[5\]\[12\] VGND VGND VPWR VPWR net1799 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10816_ clknet_leaf_97_clk _00875_ VGND VGND VPWR VPWR instr_xor sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_136_2511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10747_ clknet_leaf_100_clk _00838_ VGND VGND VPWR VPWR latched_store sky130_fd_sc_hd__dfxtp_1
X_10678_ clknet_leaf_90_clk _04904_ VGND VGND VPWR VPWR reg_out\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput207 net207 VGND VGND VPWR VPWR pcpi_rs2[13] sky130_fd_sc_hd__buf_2
Xoutput218 net218 VGND VGND VPWR VPWR pcpi_rs2[23] sky130_fd_sc_hd__buf_2
XFILLER_142_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput229 net229 VGND VGND VPWR VPWR pcpi_rs2[4] sky130_fd_sc_hd__buf_2
XFILLER_141_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06840_ cpuregs\[20\]\[19\] cpuregs\[21\]\[19\] cpuregs\[22\]\[19\] cpuregs\[23\]\[19\]
+ net795 net758 VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__mux4_1
XFILLER_68_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_147_2684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06771_ _03178_ _03179_ _03183_ _03184_ net657 net729 VGND VGND VPWR VPWR _03190_
+ sky130_fd_sc_hd__mux4_1
XFILLER_49_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09490_ net2005 net273 net391 VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__mux2_1
X_08510_ _04211_ mem_do_rinst _04208_ VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__mux2_1
X_05722_ _02140_ _02289_ _02141_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__a21bo_1
XFILLER_36_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08441_ net798 cpuregs\[10\]\[31\] VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__and2b_1
X_05653_ _02100_ _02232_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__or2_1
XFILLER_51_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08372_ count_cycle\[40\] count_cycle\[41\] _04125_ VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__and3_1
X_05584_ net879 net125 VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__nand2_1
X_07323_ net1233 net250 net452 VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__mux2_1
X_07254_ net1475 net261 net461 VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__mux2_1
XFILLER_136_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06205_ net289 net2011 net478 VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__mux2_1
X_07185_ net1910 net258 net468 VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_52_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06136_ reg_pc\[5\] _02593_ VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__nor2_1
XFILLER_132_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06067_ _02536_ decoded_imm_j\[2\] net811 VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__mux2_1
Xfanout401 _04828_ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__buf_2
Xfanout412 net413 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__clkbuf_8
Xfanout423 net424 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__clkbuf_8
XFILLER_59_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05018_ _01634_ _01637_ net977 VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__or3b_1
XFILLER_48_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout445 _03573_ VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__clkbuf_4
Xfanout456 net457 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__clkbuf_8
XFILLER_86_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout434 net435 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__clkbuf_8
X_09826_ net254 net2046 net352 VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__mux2_1
Xfanout478 _02581_ VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__clkbuf_8
XFILLER_74_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout489 net491 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__clkbuf_4
XFILLER_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout467 _03562_ VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__buf_4
X_09757_ net263 net1991 net359 VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__mux2_1
X_06969_ decoded_imm\[24\] net858 VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_87_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08708_ _04392_ _04393_ net672 VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__mux2_1
X_09688_ net1853 net275 net367 VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__mux2_1
XFILLER_70_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08639_ net890 _04328_ net664 VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__a21o_1
XFILLER_147_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10601_ clknet_leaf_86_clk _00725_ VGND VGND VPWR VPWR count_cycle\[18\] sky130_fd_sc_hd__dfxtp_1
X_10532_ clknet_leaf_134_clk _00656_ VGND VGND VPWR VPWR reg_pc\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_70_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10463_ clknet_leaf_108_clk _00587_ VGND VGND VPWR VPWR count_instr\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_142_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10394_ clknet_leaf_114_clk _00518_ VGND VGND VPWR VPWR cpuregs\[20\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11015_ clknet_leaf_1_clk _01071_ VGND VGND VPWR VPWR cpuregs\[19\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_129_2392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout990 net34 VGND VGND VPWR VPWR net990 sky130_fd_sc_hd__clkbuf_4
XFILLER_73_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_811 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_109_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload11 clknet_4_13_0_clk VGND VGND VPWR VPWR clkload11/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload44 clknet_leaf_21_clk VGND VGND VPWR VPWR clkload44/Y sky130_fd_sc_hd__inv_6
Xclkload22 clknet_leaf_8_clk VGND VGND VPWR VPWR clkload22/Y sky130_fd_sc_hd__inv_6
XFILLER_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload33 clknet_leaf_142_clk VGND VGND VPWR VPWR clkload33/Y sky130_fd_sc_hd__clkinv_4
Xclkload77 clknet_leaf_45_clk VGND VGND VPWR VPWR clkload77/X sky130_fd_sc_hd__clkbuf_8
Xclkload66 clknet_leaf_43_clk VGND VGND VPWR VPWR clkload66/Y sky130_fd_sc_hd__inv_8
XFILLER_127_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload55 clknet_leaf_30_clk VGND VGND VPWR VPWR clkload55/Y sky130_fd_sc_hd__inv_12
Xclkload99 clknet_leaf_134_clk VGND VGND VPWR VPWR clkload99/Y sky130_fd_sc_hd__inv_6
Xclkload88 clknet_leaf_122_clk VGND VGND VPWR VPWR clkload88/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_149_2713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08990_ decoded_imm\[27\] net599 net628 VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__a21o_1
XFILLER_130_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_118_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07941_ net688 reg_next_pc\[5\] net545 _03701_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__a22o_1
X_07872_ _03714_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__inv_2
X_06823_ _03236_ _03237_ _03238_ _03239_ net728 net724 VGND VGND VPWR VPWR _03240_
+ sky130_fd_sc_hd__mux4_2
XFILLER_95_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09611_ net320 net1489 net373 VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__mux2_1
XFILLER_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06754_ net177 net510 VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__or2_1
XFILLER_37_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09542_ net2021 net336 net381 VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__mux2_1
XFILLER_52_800 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05705_ _02278_ _02279_ net543 VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_leaf_90_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_90_clk sky130_fd_sc_hd__clkbuf_8
X_06685_ cpuregs\[20\]\[13\] cpuregs\[21\]\[13\] cpuregs\[22\]\[13\] cpuregs\[23\]\[13\]
+ net780 net744 VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__mux4_1
X_09473_ net2190 net475 net389 VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__mux2_1
X_08424_ net2245 _04160_ net1000 VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__o21ai_1
X_05636_ net212 net867 VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_82_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_127_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05567_ net872 net208 VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__or2_1
X_08355_ count_cycle\[34\] _04115_ count_cycle\[35\] VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__a21o_1
XFILLER_138_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload5 clknet_4_6_0_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_6
X_07306_ net1483 net322 net450 VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__mux2_1
XFILLER_149_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05498_ _02068_ _02077_ VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__nand2b_1
X_08286_ count_cycle\[7\] count_cycle\[8\] count_cycle\[9\] _04070_ VGND VGND VPWR
+ VPWR _04075_ sky130_fd_sc_hd__and4_1
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07237_ net1499 net337 net458 VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__mux2_1
XFILLER_117_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07168_ net1428 net328 net466 VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__mux2_1
XFILLER_105_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06119_ reg_out\[1\] alu_out_q\[1\] net841 VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__mux2_1
X_07099_ _03498_ _03499_ net655 VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_136_Left_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout253 net254 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_2
Xfanout242 _02705_ VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__clkbuf_2
Xfanout264 _02679_ VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_87_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout275 _02666_ VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_2
Xfanout297 net298 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_2
Xfanout286 _02658_ VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlymetal6s2s_1
X_09809_ net325 net2188 net349 VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__mux2_1
XFILLER_74_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_81_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_81_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_91_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11495_ clknet_leaf_45_clk _01533_ VGND VGND VPWR VPWR cpuregs\[10\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10515_ clknet_leaf_82_clk _00639_ VGND VGND VPWR VPWR count_instr\[58\] sky130_fd_sc_hd__dfxtp_1
X_10446_ clknet_leaf_39_clk _00570_ VGND VGND VPWR VPWR cpuregs\[17\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10377_ clknet_leaf_25_clk _00501_ VGND VGND VPWR VPWR cpuregs\[25\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_2632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_144_2643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_72_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_72_clk sky130_fd_sc_hd__clkbuf_8
X_06470_ cpuregs\[12\]\[5\] cpuregs\[13\]\[5\] cpuregs\[14\]\[5\] cpuregs\[15\]\[5\]
+ net777 net741 VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__mux4_1
X_05421_ _02001_ _02004_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_47_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08140_ _03943_ _03948_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_16_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05352_ net16 net597 net587 VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__a21o_1
Xclkload122 clknet_leaf_94_clk VGND VGND VPWR VPWR clkload122/Y sky130_fd_sc_hd__inv_6
X_05283_ count_cycle\[17\] net619 net591 _01877_ VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__o211a_1
X_08071_ decoded_imm_j\[15\] _03711_ _03873_ VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__a21oi_1
Xclkload111 clknet_leaf_103_clk VGND VGND VPWR VPWR clkload111/Y sky130_fd_sc_hd__clkinvlp_4
XTAP_TAPCELL_ROW_60_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload100 clknet_leaf_108_clk VGND VGND VPWR VPWR clkload100/Y sky130_fd_sc_hd__clkinv_8
Xclkload144 clknet_leaf_79_clk VGND VGND VPWR VPWR clkload144/Y sky130_fd_sc_hd__clkinv_4
Xclkload133 clknet_leaf_82_clk VGND VGND VPWR VPWR clkload133/Y sky130_fd_sc_hd__clkinv_2
X_07022_ _03429_ _03430_ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__nand2_1
XFILLER_115_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08973_ cpuregs\[20\]\[27\] cpuregs\[21\]\[27\] cpuregs\[22\]\[27\] cpuregs\[23\]\[27\]
+ net969 net934 VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__mux4_1
XFILLER_103_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold17 cpuregs\[0\]\[21\] VGND VGND VPWR VPWR net1125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 cpuregs\[0\]\[10\] VGND VGND VPWR VPWR net1136 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07924_ _03747_ _03748_ _03749_ VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__and3b_1
XFILLER_152_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold39 mem_wordsize\[0\] VGND VGND VPWR VPWR net1147 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_110_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_83_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07855_ _02618_ reg_next_pc\[10\] net569 VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__mux2_2
X_06806_ _03220_ _03222_ net610 VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__a21oi_1
XFILLER_84_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07786_ net2286 _03662_ _03664_ VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_67_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04998_ net698 _01617_ _01621_ VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__a21o_1
XFILLER_45_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09525_ net1294 net265 net387 VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__mux2_1
X_06737_ _03147_ _03148_ net647 VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__mux2_1
XFILLER_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09456_ net276 net2176 net394 VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_63_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_63_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_80_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06668_ decoded_imm\[13\] net873 VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__nand2_1
XFILLER_25_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08407_ count_cycle\[52\] count_cycle\[53\] count_cycle\[54\] _04146_ VGND VGND VPWR
+ VPWR _04151_ sky130_fd_sc_hd__and4_1
X_05619_ net207 net873 VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__and2b_1
XFILLER_52_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06599_ cpuregs\[28\]\[10\] cpuregs\[29\]\[10\] cpuregs\[30\]\[10\] cpuregs\[31\]\[10\]
+ net782 net746 VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__mux4_1
X_09387_ net834 decoded_imm_j\[5\] _04826_ mem_rdata_q\[25\] net551 VGND VGND VPWR
+ VPWR _04856_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_35_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08338_ net2258 _04105_ _04107_ VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__a21oi_1
X_08269_ _04064_ net983 _04063_ VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__and3b_1
XFILLER_137_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11280_ clknet_leaf_123_clk _01321_ VGND VGND VPWR VPWR cpuregs\[4\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_10300_ clknet_leaf_128_clk _00424_ VGND VGND VPWR VPWR cpuregs\[26\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_111_2108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10231_ clknet_leaf_24_clk _00355_ VGND VGND VPWR VPWR cpuregs\[14\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_95_1852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10162_ clknet_leaf_51_clk _00286_ VGND VGND VPWR VPWR cpuregs\[21\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10093_ clknet_leaf_38_clk _00217_ VGND VGND VPWR VPWR cpuregs\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_126_2351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10995_ clknet_leaf_36_clk _01051_ VGND VGND VPWR VPWR cpuregs\[18\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_54_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_54_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_104_1992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11616_ net124 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__buf_1
XFILLER_11_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold509 cpuregs\[10\]\[1\] VGND VGND VPWR VPWR net1617 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_109_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11478_ clknet_leaf_140_clk _01516_ VGND VGND VPWR VPWR cpuregs\[10\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_10429_ clknet_leaf_149_clk _00553_ VGND VGND VPWR VPWR cpuregs\[17\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05970_ net880 _02487_ net634 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__mux2_1
Xhold1209 mem_state\[0\] VGND VGND VPWR VPWR net2317 sky130_fd_sc_hd__dlygate4sd3_1
X_04921_ instr_jalr VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__inv_2
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07640_ net321 net1348 net410 VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__mux2_1
XFILLER_80_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07571_ net1950 net328 net418 VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__mux2_1
XFILLER_19_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_45_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_45_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_81_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09310_ net131 net407 _04814_ _04204_ VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__o211a_1
XFILLER_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06522_ cpuregs\[16\]\[7\] cpuregs\[17\]\[7\] cpuregs\[18\]\[7\] cpuregs\[19\]\[7\]
+ net774 net738 VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__mux4_1
Xpicorv32_1105 VGND VGND VPWR VPWR picorv32_1105/HI trace_data[33] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_62_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09241_ net1943 net308 net404 VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__mux2_1
XFILLER_22_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06453_ net876 net515 VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__or2_1
X_05404_ _01987_ _01988_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__xnor2_1
X_09172_ _04780_ _04785_ instr_rdcycle net549 VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__a2bb2o_1
X_06384_ net733 _02815_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__and2_1
XFILLER_119_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05335_ reg_pc\[22\] decoded_imm\[22\] VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__nand2_1
X_08123_ _03919_ _03925_ VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__or2_1
XFILLER_119_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08054_ net991 _03869_ VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__and2_1
X_07005_ cpuregs\[12\]\[25\] cpuregs\[13\]\[25\] cpuregs\[14\]\[25\] cpuregs\[15\]\[25\]
+ net803 net766 VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__mux4_1
X_05266_ _01855_ _01857_ _01858_ _01861_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_77_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05197_ net827 count_cycle\[43\] count_cycle\[11\] net625 _01797_ VGND VGND VPWR
+ VPWR _01798_ sky130_fd_sc_hd__a221o_1
XFILLER_143_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_90_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08956_ cpuregs\[20\]\[26\] cpuregs\[21\]\[26\] cpuregs\[22\]\[26\] cpuregs\[23\]\[26\]
+ net966 net931 VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__mux4_1
X_08887_ cpuregs\[0\]\[22\] cpuregs\[1\]\[22\] cpuregs\[2\]\[22\] cpuregs\[3\]\[22\]
+ net964 net929 VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__mux4_1
XFILLER_57_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07907_ _03729_ _03734_ VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__xor2_1
XFILLER_17_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07838_ _02587_ reg_next_pc\[2\] net571 VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__mux2_2
XFILLER_29_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_36_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_36_clk sky130_fd_sc_hd__clkbuf_8
X_07769_ count_instr\[39\] _03652_ net981 VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__o21ai_1
X_09508_ net1306 net341 net385 VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_121_2270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10780_ clknet_leaf_63_clk alu_out\[27\] VGND VGND VPWR VPWR alu_out_q\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_80_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09439_ net493 net2133 net396 VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__mux2_1
XFILLER_24_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11401_ clknet_leaf_68_clk _01439_ VGND VGND VPWR VPWR cpuregs\[7\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_80 net643 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_91 net846 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11332_ clknet_leaf_46_clk _01373_ VGND VGND VPWR VPWR cpuregs\[5\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11263_ clknet_leaf_34_clk _01304_ VGND VGND VPWR VPWR cpuregs\[22\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_134_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10214_ clknet_leaf_28_clk _00338_ VGND VGND VPWR VPWR cpuregs\[14\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_11194_ clknet_leaf_11_clk _01235_ VGND VGND VPWR VPWR cpuregs\[29\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10145_ clknet_leaf_153_clk _00269_ VGND VGND VPWR VPWR cpuregs\[21\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10076_ clknet_leaf_142_clk _00200_ VGND VGND VPWR VPWR cpuregs\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_90_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_27_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_63_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10978_ clknet_leaf_144_clk _01034_ VGND VGND VPWR VPWR cpuregs\[18\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_30_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05120_ _01718_ _01721_ _01726_ net711 VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_152_2764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold317 cpuregs\[13\]\[15\] VGND VGND VPWR VPWR net1425 sky130_fd_sc_hd__dlygate4sd3_1
Xhold306 net65 VGND VGND VPWR VPWR net1414 sky130_fd_sc_hd__dlygate4sd3_1
Xhold339 cpuregs\[27\]\[21\] VGND VGND VPWR VPWR net1447 sky130_fd_sc_hd__dlygate4sd3_1
X_05051_ net887 net707 decoded_imm\[0\] net713 net589 VGND VGND VPWR VPWR _01663_
+ sky130_fd_sc_hd__a221o_1
Xhold328 cpuregs\[24\]\[8\] VGND VGND VPWR VPWR net1436 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout808 net809 VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__clkbuf_4
XFILLER_112_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08810_ net902 _04490_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__or2_1
XFILLER_97_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout819 net820 VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__clkbuf_4
X_09790_ net264 net2219 net355 VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__mux2_1
XFILLER_112_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1006 cpuregs\[21\]\[8\] VGND VGND VPWR VPWR net2114 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1017 cpuregs\[19\]\[29\] VGND VGND VPWR VPWR net2125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1028 cpuregs\[16\]\[20\] VGND VGND VPWR VPWR net2136 sky130_fd_sc_hd__dlygate4sd3_1
X_05953_ net126 net218 net594 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__mux2_1
XFILLER_100_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08741_ cpuregs\[0\]\[14\] cpuregs\[1\]\[14\] cpuregs\[2\]\[14\] cpuregs\[3\]\[14\]
+ net958 net923 VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_72_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1039 instr_blt VGND VGND VPWR VPWR net2147 sky130_fd_sc_hd__dlygate4sd3_1
X_05884_ _02105_ _02245_ net586 VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__o21ba_1
X_08672_ net900 _04353_ net890 VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__o21a_1
XFILLER_38_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07623_ net1882 net252 net416 VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__mux2_1
XFILLER_66_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_18_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07554_ net259 net2107 net424 VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__mux2_1
X_07485_ net1423 net269 net432 VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__mux2_1
X_06505_ net1960 net303 _02933_ VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__a21o_1
XFILLER_139_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09224_ net2239 net548 _04800_ is_alu_reg_reg VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__a22o_1
X_06436_ _02865_ _02866_ VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_79_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09155_ net2182 net499 _04768_ _04773_ VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__a22o_1
X_06367_ cpuregs\[8\]\[2\] cpuregs\[9\]\[2\] cpuregs\[10\]\[2\] cpuregs\[11\]\[2\]
+ net788 net752 VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__mux4_1
X_05318_ count_cycle\[20\] net618 VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__or2_1
X_08106_ net689 reg_next_pc\[18\] net546 _03714_ VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__a22o_1
X_09086_ net2353 net27 net614 VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__mux2_1
X_06298_ net850 cpu_state\[5\] net984 VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__a21boi_1
XFILLER_116_760 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08037_ _03847_ _03853_ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__xnor2_1
X_05249_ net695 _01747_ net596 VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__a21o_1
XFILLER_150_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold851 cpuregs\[15\]\[25\] VGND VGND VPWR VPWR net1959 sky130_fd_sc_hd__dlygate4sd3_1
Xhold840 cpuregs\[23\]\[18\] VGND VGND VPWR VPWR net1948 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold862 cpuregs\[28\]\[13\] VGND VGND VPWR VPWR net1970 sky130_fd_sc_hd__dlygate4sd3_1
Xhold873 cpuregs\[16\]\[5\] VGND VGND VPWR VPWR net1981 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold895 cpuregs\[20\]\[2\] VGND VGND VPWR VPWR net2003 sky130_fd_sc_hd__dlygate4sd3_1
Xhold884 cpuregs\[19\]\[2\] VGND VGND VPWR VPWR net1992 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09988_ clknet_leaf_12_clk _00112_ VGND VGND VPWR VPWR cpuregs\[12\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_08939_ cpuregs\[4\]\[25\] cpuregs\[5\]\[25\] cpuregs\[6\]\[25\] cpuregs\[7\]\[25\]
+ net970 net935 VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_150_Right_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_2029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10901_ clknet_leaf_145_clk _00957_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dfxtp_1
XFILLER_72_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10832_ clknet_leaf_93_clk _00891_ VGND VGND VPWR VPWR decoded_imm_j\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_60_728 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10763_ clknet_leaf_134_clk alu_out\[10\] VGND VGND VPWR VPWR alu_out_q\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_101_1951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10694_ clknet_leaf_84_clk _00786_ VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfxtp_1
XFILLER_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_134_2483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11315_ clknet_leaf_146_clk _01356_ VGND VGND VPWR VPWR cpuregs\[5\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11246_ clknet_leaf_122_clk _01287_ VGND VGND VPWR VPWR cpuregs\[22\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_11177_ clknet_leaf_73_clk _01218_ VGND VGND VPWR VPWR cpuregs\[23\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_10128_ clknet_leaf_65_clk _00252_ VGND VGND VPWR VPWR cpuregs\[28\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10059_ clknet_leaf_22_clk _00183_ VGND VGND VPWR VPWR cpuregs\[13\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07270_ net1572 net335 net454 VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__mux2_1
X_06221_ net277 net2052 net478 VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__mux2_1
XFILLER_148_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_145_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06152_ reg_pc\[8\] _02607_ VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__xor2_1
Xhold114 net46 VGND VGND VPWR VPWR net1222 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_145_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold125 cpuregs\[28\]\[28\] VGND VGND VPWR VPWR net1233 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 cpuregs\[30\]\[28\] VGND VGND VPWR VPWR net1211 sky130_fd_sc_hd__dlygate4sd3_1
X_05103_ count_instr\[36\] net815 net824 count_cycle\[36\] VGND VGND VPWR VPWR _01711_
+ sky130_fd_sc_hd__a22o_1
X_06083_ cpuregs\[28\]\[3\] cpuregs\[29\]\[3\] cpuregs\[30\]\[3\] cpuregs\[31\]\[3\]
+ net953 net918 VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__mux4_1
XFILLER_144_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_7_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_57_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05034_ cpu_state\[5\] _01622_ _01635_ VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__and3_1
X_09911_ clknet_leaf_126_clk _00040_ VGND VGND VPWR VPWR cpuregs\[11\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold136 cpuregs\[30\]\[4\] VGND VGND VPWR VPWR net1244 sky130_fd_sc_hd__dlygate4sd3_1
Xhold158 cpuregs\[1\]\[8\] VGND VGND VPWR VPWR net1266 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 cpuregs\[15\]\[11\] VGND VGND VPWR VPWR net1255 sky130_fd_sc_hd__dlygate4sd3_1
Xhold169 cpuregs\[28\]\[29\] VGND VGND VPWR VPWR net1277 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout605 _01618_ VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_903 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout616 _01577_ VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__buf_2
Xfanout627 net628 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09842_ _02620_ net2063 net345 VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__mux2_1
Xfanout638 net640 VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__clkbuf_8
Xfanout649 _01567_ VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_70_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09773_ net340 net1852 net353 VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__mux2_1
X_06985_ net735 _03395_ VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__or2_1
XFILLER_100_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08724_ net672 _04409_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__or2_1
XFILLER_94_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05936_ net696 net122 net205 net694 VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__a22o_1
XFILLER_54_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05867_ _02092_ _02421_ net543 VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__a21o_1
XFILLER_66_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08655_ _04335_ _04343_ _04344_ net658 net895 VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__a221o_1
XFILLER_81_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07606_ net1673 net324 net414 VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__mux2_1
X_08586_ cpuregs\[20\]\[6\] cpuregs\[21\]\[6\] cpuregs\[22\]\[6\] cpuregs\[23\]\[6\]
+ net945 net910 VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__mux4_1
X_05798_ _02112_ _02361_ net579 _02110_ VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__a2bb2o_1
XTAP_TAPCELL_ROW_85_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07537_ net336 net1996 net422 VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__mux2_1
XFILLER_22_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07468_ net1243 net472 net430 VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__mux2_1
XFILLER_136_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07399_ net1725 net492 net439 VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__mux2_1
X_06419_ cpuregs\[8\]\[4\] cpuregs\[9\]\[4\] cpuregs\[10\]\[4\] cpuregs\[11\]\[4\]
+ net785 net749 VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__mux4_1
X_09207_ net2328 net2 net612 VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__mux2_1
X_09138_ net2120 net500 _04756_ _04767_ VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_20_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11100_ clknet_leaf_65_clk _01151_ VGND VGND VPWR VPWR cpuregs\[24\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09069_ is_beq_bne_blt_bge_bltu_bgeu instr_jalr VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__or2_1
XFILLER_2_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold670 cpuregs\[31\]\[31\] VGND VGND VPWR VPWR net1778 sky130_fd_sc_hd__dlygate4sd3_1
Xhold681 cpuregs\[2\]\[31\] VGND VGND VPWR VPWR net1789 sky130_fd_sc_hd__dlygate4sd3_1
Xhold692 cpuregs\[1\]\[27\] VGND VGND VPWR VPWR net1800 sky130_fd_sc_hd__dlygate4sd3_1
X_11031_ clknet_leaf_50_clk _01087_ VGND VGND VPWR VPWR cpuregs\[19\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_9_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_850 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10815_ clknet_leaf_96_clk _00874_ VGND VGND VPWR VPWR instr_sltu sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_28_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10746_ clknet_leaf_56_clk _00837_ VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dfxtp_4
X_10677_ clknet_leaf_90_clk _04902_ VGND VGND VPWR VPWR reg_out\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_127_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput208 net208 VGND VGND VPWR VPWR pcpi_rs2[14] sky130_fd_sc_hd__buf_2
Xoutput219 net219 VGND VGND VPWR VPWR pcpi_rs2[24] sky130_fd_sc_hd__buf_2
XFILLER_142_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11229_ clknet_leaf_44_clk _01270_ VGND VGND VPWR VPWR cpuregs\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_52_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06770_ _03182_ _03187_ _03188_ net728 net639 VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__a221o_1
X_05721_ _02141_ _02292_ _02293_ VGND VGND VPWR VPWR alu_out\[7\] sky130_fd_sc_hd__a21o_1
X_08440_ cpuregs\[8\]\[31\] cpuregs\[9\]\[31\] net799 VGND VGND VPWR VPWR _04174_
+ sky130_fd_sc_hd__mux2_1
X_05652_ _02088_ _02231_ _02225_ VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__a21oi_1
XFILLER_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08371_ count_cycle\[40\] _04125_ count_cycle\[41\] VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__a21o_1
X_05583_ _02161_ _02162_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__nand2b_1
XFILLER_149_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07322_ net1925 net251 net452 VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__mux2_1
X_07253_ net1452 net266 net461 VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__mux2_1
X_07184_ net1877 net261 net469 VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__mux2_1
X_06204_ _02651_ _02652_ net567 VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__mux2_2
X_06135_ reg_out\[5\] alu_out_q\[5\] net840 VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__mux2_1
XFILLER_105_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06066_ _02531_ _02535_ _02525_ net541 VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__a211oi_2
Xfanout413 _03584_ VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__clkbuf_8
XFILLER_59_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05017_ instr_rdcycle net617 _01636_ VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_6_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout402 net403 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__buf_6
X_09825_ net258 net2194 net352 VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__mux2_1
Xfanout457 _03569_ VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__buf_4
Xfanout424 net425 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__clkbuf_8
XFILLER_113_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout446 net449 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__buf_6
Xfanout435 _03576_ VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__buf_4
Xfanout479 _02581_ VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__clkbuf_4
XFILLER_104_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout468 _03562_ VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__clkbuf_8
XFILLER_86_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09756_ net268 net1892 net360 VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__mux2_1
X_06968_ decoded_imm\[24\] net858 VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_87_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09687_ net1695 net279 net367 VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__mux2_1
X_05919_ _02098_ _02461_ VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__or2_1
X_08707_ net900 _04386_ net890 VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__o21a_1
XFILLER_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06899_ cpuregs\[24\]\[21\] cpuregs\[25\]\[21\] cpuregs\[26\]\[21\] cpuregs\[27\]\[21\]
+ net798 net761 VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__mux4_1
X_08638_ net899 _04324_ _04323_ net658 VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__o211a_1
XFILLER_55_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08569_ cpuregs\[24\]\[5\] cpuregs\[25\]\[5\] cpuregs\[26\]\[5\] cpuregs\[27\]\[5\]
+ net945 net910 VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__mux4_1
X_10600_ clknet_leaf_86_clk _00724_ VGND VGND VPWR VPWR count_cycle\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_80_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_118_2220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10531_ clknet_leaf_134_clk _00655_ VGND VGND VPWR VPWR reg_pc\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10462_ clknet_leaf_107_clk _00586_ VGND VGND VPWR VPWR count_instr\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_131_2431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_2420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10393_ clknet_leaf_120_clk _00517_ VGND VGND VPWR VPWR cpuregs\[20\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_150_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_104_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11014_ clknet_leaf_3_clk _01070_ VGND VGND VPWR VPWR cpuregs\[19\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_129_2393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout991 net1002 VGND VGND VPWR VPWR net991 sky130_fd_sc_hd__clkbuf_4
XFILLER_65_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout980 net982 VGND VGND VPWR VPWR net980 sky130_fd_sc_hd__clkbuf_2
XFILLER_46_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10729_ clknet_leaf_21_clk _00820_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dfxtp_2
XFILLER_9_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload12 clknet_4_14_0_clk VGND VGND VPWR VPWR clkload12/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload23 clknet_leaf_9_clk VGND VGND VPWR VPWR clkload23/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload34 clknet_leaf_143_clk VGND VGND VPWR VPWR clkload34/Y sky130_fd_sc_hd__clkinv_8
Xclkload78 clknet_leaf_46_clk VGND VGND VPWR VPWR clkload78/Y sky130_fd_sc_hd__inv_8
Xclkload56 clknet_leaf_31_clk VGND VGND VPWR VPWR clkload56/Y sky130_fd_sc_hd__inv_6
Xclkload67 clknet_leaf_20_clk VGND VGND VPWR VPWR clkload67/Y sky130_fd_sc_hd__inv_6
Xclkload45 clknet_leaf_135_clk VGND VGND VPWR VPWR clkload45/Y sky130_fd_sc_hd__clkinv_8
XFILLER_141_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload89 clknet_leaf_123_clk VGND VGND VPWR VPWR clkload89/Y sky130_fd_sc_hd__bufinv_16
XTAP_TAPCELL_ROW_149_2714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07940_ net687 _03760_ _03761_ _03764_ VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__o31ai_1
XFILLER_95_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07871_ _02651_ reg_next_pc\[18\] net574 VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__mux2_2
XFILLER_29_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06822_ _03234_ _03235_ net651 VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__mux2_1
XFILLER_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09610_ net323 net2210 net373 VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__mux2_1
X_06753_ _03170_ _03167_ VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_69_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09541_ net1398 net339 net381 VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__mux2_1
XFILLER_37_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05704_ _02172_ _02277_ VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__nand2_1
XFILLER_36_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06684_ cpuregs\[0\]\[13\] cpuregs\[1\]\[13\] cpuregs\[2\]\[13\] cpuregs\[3\]\[13\]
+ net780 net744 VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__mux4_1
X_09472_ net1299 net494 net390 VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__mux2_1
XFILLER_36_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08423_ count_cycle\[58\] count_cycle\[59\] count_cycle\[60\] _04157_ VGND VGND VPWR
+ VPWR _04161_ sky130_fd_sc_hd__and4_1
X_05635_ net213 net865 VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_82_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05566_ net872 net208 VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__and2_1
X_08354_ net2291 _04115_ _04117_ VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__a21oi_1
X_07305_ net1937 net325 net450 VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__mux2_1
Xclkload6 clknet_4_7_0_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__clkinvlp_4
X_05497_ _02072_ _02076_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__and2_1
X_08285_ _04074_ net985 _04073_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__and3b_1
X_07236_ net1256 net340 net458 VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__mux2_1
XFILLER_152_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07167_ net1531 net337 net466 VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__mux2_1
XFILLER_133_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06118_ net538 net1562 net476 VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__mux2_1
X_07098_ _03500_ _03501_ net655 VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__mux2_1
XFILLER_106_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06049_ cpuregs\[0\]\[2\] cpuregs\[1\]\[2\] cpuregs\[2\]\[2\] cpuregs\[3\]\[2\] net955
+ net920 VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__mux4_1
Xfanout254 _02692_ VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_2
Xfanout243 _02700_ VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__buf_2
Xfanout265 _02679_ VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_2
XFILLER_115_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout276 _02666_ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_1
Xfanout298 _02645_ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__clkbuf_2
Xfanout287 _02653_ VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__clkbuf_2
XFILLER_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09808_ net328 net1792 net349 VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__mux2_1
X_09739_ net470 net2230 net357 VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__mux2_1
XFILLER_74_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11494_ clknet_leaf_42_clk _01532_ VGND VGND VPWR VPWR cpuregs\[10\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_10514_ clknet_leaf_82_clk _00638_ VGND VGND VPWR VPWR count_instr\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10445_ clknet_leaf_36_clk _00569_ VGND VGND VPWR VPWR cpuregs\[17\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10376_ clknet_leaf_53_clk _00500_ VGND VGND VPWR VPWR cpuregs\[25\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_144_2633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_92_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05420_ _02002_ _02003_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__nand2_1
XFILLER_60_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05351_ _01938_ _01939_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_16_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_147_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05282_ net826 count_cycle\[49\] net624 _01876_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__a211o_1
X_08070_ _03881_ _03882_ VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__and2_1
Xclkload112 clknet_leaf_104_clk VGND VGND VPWR VPWR clkload112/Y sky130_fd_sc_hd__clkinvlp_4
XTAP_TAPCELL_ROW_60_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload101 clknet_leaf_112_clk VGND VGND VPWR VPWR clkload101/Y sky130_fd_sc_hd__clkinv_8
XFILLER_134_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload145 clknet_leaf_80_clk VGND VGND VPWR VPWR clkload145/Y sky130_fd_sc_hd__clkinvlp_4
X_07021_ decoded_imm\[26\] net856 VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__nand2_1
Xclkload134 clknet_leaf_83_clk VGND VGND VPWR VPWR clkload134/Y sky130_fd_sc_hd__clkinv_2
Xclkload123 clknet_leaf_95_clk VGND VGND VPWR VPWR clkload123/Y sky130_fd_sc_hd__inv_8
XFILLER_142_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08972_ net221 net632 _04643_ _04644_ VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__o22a_1
Xhold18 cpuregs\[0\]\[18\] VGND VGND VPWR VPWR net1126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 cpuregs\[0\]\[15\] VGND VGND VPWR VPWR net1137 sky130_fd_sc_hd__dlygate4sd3_1
X_07923_ decoded_imm_j\[4\] _03700_ VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__nand2_1
X_07854_ reg_pc\[9\] net502 _03705_ net602 VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__a22o_1
XFILLER_56_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06805_ _03193_ _03198_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__nand2_1
XFILLER_83_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07785_ count_instr\[45\] _03662_ net988 VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__o21ai_1
X_04997_ instr_sb _01606_ _01619_ _01578_ VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__a22o_1
X_09524_ net1690 net269 net388 VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__mux2_1
X_06736_ _03153_ _03154_ net647 VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__mux2_1
XFILLER_45_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09455_ net280 net1931 net394 VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__mux2_1
X_06667_ net874 _03089_ net304 VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__mux2_1
X_08406_ _04150_ net998 _04149_ VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__and3b_1
X_05618_ _02120_ _02197_ _02196_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__o21a_1
XFILLER_25_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06598_ net732 _03022_ VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__or2_1
X_09386_ net2376 net552 _04855_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_35_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08337_ count_cycle\[28\] _04105_ net993 VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__o21ai_1
X_05549_ _02126_ _02128_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__nand2_2
XFILLER_137_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08268_ count_cycle\[0\] count_cycle\[1\] count_cycle\[2\] VGND VGND VPWR VPWR _04064_
+ sky130_fd_sc_hd__and3_1
X_07219_ net1642 net266 net463 VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__mux2_1
X_10230_ clknet_leaf_74_clk _00354_ VGND VGND VPWR VPWR cpuregs\[14\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_08199_ _03989_ _03993_ _04001_ net837 VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_111_2109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10161_ clknet_leaf_51_clk _00285_ VGND VGND VPWR VPWR cpuregs\[21\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10092_ clknet_leaf_37_clk _00216_ VGND VGND VPWR VPWR cpuregs\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10994_ clknet_leaf_33_clk _01050_ VGND VGND VPWR VPWR cpuregs\[18\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_74_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_494 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11615_ net123 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_13_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11477_ clknet_leaf_139_clk _01515_ VGND VGND VPWR VPWR cpuregs\[10\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_10428_ clknet_leaf_144_clk _00552_ VGND VGND VPWR VPWR cpuregs\[17\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10359_ clknet_leaf_56_clk _00483_ VGND VGND VPWR VPWR cpuregs\[16\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04920_ reg_pc\[2\] VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__inv_2
XFILLER_93_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_425 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_49_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07570_ net1286 net335 net418 VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__mux2_1
X_06521_ cpuregs\[20\]\[7\] cpuregs\[21\]\[7\] cpuregs\[22\]\[7\] cpuregs\[23\]\[7\]
+ net774 net738 VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__mux4_1
XFILLER_34_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09240_ net1236 net312 net402 VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xpicorv32_1106 VGND VGND VPWR VPWR picorv32_1106/HI trace_data[34] sky130_fd_sc_hd__conb_1
XFILLER_22_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06452_ net609 _02879_ _02880_ _02881_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__and4bb_1
X_05403_ _01975_ _01978_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__nand2_1
X_09171_ _04785_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__inv_2
X_06383_ cpuregs\[12\]\[3\] cpuregs\[13\]\[3\] cpuregs\[14\]\[3\] cpuregs\[15\]\[3\]
+ net786 net750 VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_32_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05334_ reg_pc\[22\] decoded_imm\[22\] VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__or2_1
X_08122_ net813 _03717_ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__xor2_1
XFILLER_30_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08053_ net559 _03867_ _03868_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__a21o_1
X_07004_ cpuregs\[28\]\[25\] cpuregs\[29\]\[25\] cpuregs\[30\]\[25\] cpuregs\[31\]\[25\]
+ net804 net767 VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__mux4_1
X_05265_ _01859_ _01860_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05196_ count_instr\[43\] net818 net820 count_instr\[11\] VGND VGND VPWR VPWR _01797_
+ sky130_fd_sc_hd__a22o_1
XFILLER_103_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_826 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08955_ cpuregs\[28\]\[26\] cpuregs\[29\]\[26\] cpuregs\[30\]\[26\] cpuregs\[31\]\[26\]
+ net969 net934 VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__mux4_1
XFILLER_130_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07906_ decoded_imm_j\[2\] _03697_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__xor2_1
X_08886_ cpuregs\[4\]\[22\] cpuregs\[5\]\[22\] cpuregs\[6\]\[22\] cpuregs\[7\]\[22\]
+ net964 net929 VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__mux4_1
XFILLER_96_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_108_2060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07837_ net691 reg_pc\[1\] net977 _03696_ VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__a31o_1
XFILLER_72_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07768_ _03652_ _03653_ VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__nor2_1
XFILLER_44_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06719_ decoded_imm\[15\] net871 VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__nand2_1
X_09507_ net1316 net471 net385 VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_121_2271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07699_ _03608_ _03609_ VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__nor2_1
X_09438_ net528 net1712 net396 VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__mux2_1
XFILLER_24_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09369_ decoded_imm\[14\] net555 _04827_ _04846_ VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__o22a_1
XFILLER_12_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11400_ clknet_leaf_53_clk _01438_ VGND VGND VPWR VPWR cpuregs\[7\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11331_ clknet_leaf_40_clk _01372_ VGND VGND VPWR VPWR cpuregs\[5\]\[22\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_70 net431 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_92 net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_81 net665 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11262_ clknet_leaf_28_clk _01303_ VGND VGND VPWR VPWR cpuregs\[22\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10213_ clknet_leaf_9_clk _00337_ VGND VGND VPWR VPWR cpuregs\[14\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_11193_ clknet_leaf_12_clk _01234_ VGND VGND VPWR VPWR cpuregs\[29\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10144_ clknet_leaf_14_clk _00268_ VGND VGND VPWR VPWR cpuregs\[21\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10075_ clknet_leaf_124_clk _00199_ VGND VGND VPWR VPWR cpuregs\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10977_ clknet_leaf_123_clk _01033_ VGND VGND VPWR VPWR cpuregs\[18\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_43_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_139_2554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_152_2765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold307 instr_slti VGND VGND VPWR VPWR net1415 sky130_fd_sc_hd__dlygate4sd3_1
Xhold329 cpuregs\[30\]\[8\] VGND VGND VPWR VPWR net1437 sky130_fd_sc_hd__dlygate4sd3_1
Xhold318 cpuregs\[26\]\[0\] VGND VGND VPWR VPWR net1426 sky130_fd_sc_hd__dlygate4sd3_1
X_05050_ net712 net700 net707 VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__or3_1
XFILLER_125_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout809 _00012_ VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__buf_4
XFILLER_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1007 cpuregs\[11\]\[30\] VGND VGND VPWR VPWR net2115 sky130_fd_sc_hd__dlygate4sd3_1
X_05952_ net125 net217 net594 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__mux2_1
X_08740_ net672 _04424_ VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_72_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1029 cpuregs\[16\]\[13\] VGND VGND VPWR VPWR net2137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1018 cpuregs\[24\]\[9\] VGND VGND VPWR VPWR net2126 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_39_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05883_ _02107_ _02436_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__xnor2_1
XFILLER_94_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08671_ cpuregs\[8\]\[10\] cpuregs\[9\]\[10\] cpuregs\[10\]\[10\] cpuregs\[11\]\[10\]
+ net950 net915 VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__mux4_1
XFILLER_39_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07622_ net1693 net255 net415 VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__mux2_1
XFILLER_81_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07553_ net263 net2043 net424 VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__mux2_1
X_07484_ net1308 net274 net432 VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__mux2_1
XFILLER_21_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06504_ net304 _02918_ _02932_ VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__and3_1
X_09223_ is_sb_sh_sw _02515_ _04743_ _04798_ VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__a22o_1
X_06435_ decoded_imm\[4\] net881 VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__nand2_1
XFILLER_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09154_ net2211 net499 _04762_ _04773_ VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__a22o_1
XFILLER_21_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08105_ net557 _03916_ VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__nor2_1
X_06366_ cpuregs\[12\]\[2\] cpuregs\[13\]\[2\] cpuregs\[14\]\[2\] cpuregs\[15\]\[2\]
+ net789 net753 VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__mux4_1
X_05317_ net825 count_cycle\[52\] net623 _01908_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__a211o_1
X_09085_ _04741_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__inv_2
X_06297_ net717 _02718_ VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__nor2_1
Xhold830 cpuregs\[9\]\[27\] VGND VGND VPWR VPWR net1938 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08036_ _03809_ _03817_ _03849_ _03852_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__a31o_1
X_05248_ _01844_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__inv_2
XFILLER_116_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold863 count_cycle\[18\] VGND VGND VPWR VPWR net1971 sky130_fd_sc_hd__dlygate4sd3_1
Xhold841 cpuregs\[16\]\[1\] VGND VGND VPWR VPWR net1949 sky130_fd_sc_hd__dlygate4sd3_1
Xhold852 net199 VGND VGND VPWR VPWR net1960 sky130_fd_sc_hd__dlygate4sd3_1
Xhold874 cpuregs\[14\]\[26\] VGND VGND VPWR VPWR net1982 sky130_fd_sc_hd__dlygate4sd3_1
Xhold885 cpuregs\[22\]\[29\] VGND VGND VPWR VPWR net1993 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_115_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05179_ _01779_ _01780_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__nand2_1
Xhold896 cpuregs\[7\]\[0\] VGND VGND VPWR VPWR net2004 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_77_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09987_ clknet_leaf_3_clk _00111_ VGND VGND VPWR VPWR cpuregs\[12\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_08938_ cpuregs\[16\]\[25\] cpuregs\[17\]\[25\] cpuregs\[18\]\[25\] cpuregs\[19\]\[25\]
+ net969 net934 VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__mux4_1
XFILLER_131_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08869_ cpuregs\[12\]\[21\] cpuregs\[13\]\[21\] cpuregs\[14\]\[21\] cpuregs\[15\]\[21\]
+ net963 net928 VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__mux4_1
XFILLER_69_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10900_ clknet_leaf_147_clk _00956_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dfxtp_1
XFILLER_29_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10831_ clknet_leaf_92_clk _00890_ VGND VGND VPWR VPWR decoded_imm_j\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10762_ clknet_leaf_135_clk alu_out\[9\] VGND VGND VPWR VPWR alu_out_q\[9\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10693_ clknet_leaf_49_clk _00785_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfxtp_1
XFILLER_139_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_134_2473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11314_ clknet_leaf_148_clk _01355_ VGND VGND VPWR VPWR cpuregs\[5\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11245_ clknet_leaf_138_clk _01286_ VGND VGND VPWR VPWR cpuregs\[22\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11176_ clknet_leaf_67_clk _01217_ VGND VGND VPWR VPWR cpuregs\[23\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_10127_ clknet_leaf_53_clk _00251_ VGND VGND VPWR VPWR cpuregs\[28\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_10058_ clknet_leaf_34_clk _00182_ VGND VGND VPWR VPWR cpuregs\[13\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06220_ _02662_ _02665_ net567 VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__mux2_2
XFILLER_85_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06151_ reg_out\[8\] alu_out_q\[8\] net840 VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__mux2_1
Xhold115 cpuregs\[29\]\[28\] VGND VGND VPWR VPWR net1223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold126 cpuregs\[31\]\[25\] VGND VGND VPWR VPWR net1234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold104 net38 VGND VGND VPWR VPWR net1212 sky130_fd_sc_hd__dlygate4sd3_1
X_05102_ net13 _01656_ net130 net27 _01709_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__a221o_2
X_06082_ net665 _02550_ VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__nand2_1
XFILLER_145_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold137 cpuregs\[25\]\[25\] VGND VGND VPWR VPWR net1245 sky130_fd_sc_hd__dlygate4sd3_1
Xhold159 cpuregs\[2\]\[16\] VGND VGND VPWR VPWR net1267 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05033_ net811 _01636_ _01648_ _01635_ VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__a22o_1
Xhold148 cpuregs\[13\]\[7\] VGND VGND VPWR VPWR net1256 sky130_fd_sc_hd__dlygate4sd3_1
X_09910_ clknet_leaf_118_clk _00039_ VGND VGND VPWR VPWR cpuregs\[11\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xfanout606 net608 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__buf_4
Xfanout628 net629 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__clkbuf_4
Xfanout639 net640 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__buf_4
Xfanout617 net621 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__clkbuf_4
X_09841_ net326 net1566 net345 VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__mux2_1
X_06984_ cpuregs\[16\]\[24\] cpuregs\[17\]\[24\] cpuregs\[18\]\[24\] cpuregs\[19\]\[24\]
+ net801 net762 VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__mux4_1
XFILLER_113_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09772_ net470 net1809 net353 VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__mux2_1
XFILLER_100_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08723_ cpuregs\[12\]\[13\] cpuregs\[13\]\[13\] cpuregs\[14\]\[13\] cpuregs\[15\]\[13\]
+ net948 net913 VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__mux4_1
XFILLER_67_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05935_ net696 net846 net204 net593 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__a22o_1
XFILLER_39_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05866_ _02092_ _02421_ VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_1_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08654_ _04338_ _04339_ net669 VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__mux2_1
X_05797_ _02111_ net576 net585 VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__a21oi_1
XFILLER_54_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07605_ net1536 net327 net414 VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__mux2_1
XFILLER_26_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08585_ net845 net630 _04277_ _04278_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_85_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07536_ net339 net2009 net422 VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__mux2_1
XFILLER_139_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07467_ net1670 net474 net430 VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__mux2_1
X_09206_ net1193 _01103_ net330 VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__mux2_1
XFILLER_10_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07398_ net1682 net529 net439 VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__mux2_1
X_06418_ net733 _02846_ _02848_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__a21o_1
X_09137_ net2342 net499 _04754_ _04767_ VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_20_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06349_ _02781_ _02782_ VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__nor2_1
XFILLER_136_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09068_ net712 net691 _01630_ net841 net978 VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__o221a_1
XFILLER_135_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_2192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08019_ _03823_ _03828_ _03836_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__o21ai_1
XFILLER_2_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold660 cpuregs\[5\]\[23\] VGND VGND VPWR VPWR net1768 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold671 cpuregs\[21\]\[19\] VGND VGND VPWR VPWR net1779 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold693 cpuregs\[21\]\[28\] VGND VGND VPWR VPWR net1801 sky130_fd_sc_hd__dlygate4sd3_1
X_11030_ clknet_leaf_52_clk _01086_ VGND VGND VPWR VPWR cpuregs\[19\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_77_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold682 cpuregs\[26\]\[6\] VGND VGND VPWR VPWR net1790 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_134_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10814_ clknet_leaf_96_clk _00873_ VGND VGND VPWR VPWR instr_slt sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_28_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_2513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10745_ clknet_leaf_63_clk _00836_ VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dfxtp_2
X_10676_ clknet_leaf_80_clk _04901_ VGND VGND VPWR VPWR reg_out\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput209 net209 VGND VGND VPWR VPWR pcpi_rs2[15] sky130_fd_sc_hd__buf_2
X_11228_ clknet_leaf_11_clk _01269_ VGND VGND VPWR VPWR cpuregs\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11159_ clknet_leaf_13_clk _01200_ VGND VGND VPWR VPWR cpuregs\[23\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_52_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05720_ _02140_ net581 net544 _02291_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__a2bb2o_1
X_05651_ _02104_ _02107_ _02227_ _02230_ VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__a31o_1
X_08370_ net2290 _04125_ _04127_ VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__a21oi_1
X_07321_ net1770 net256 net452 VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__mux2_1
X_05582_ net881 net123 VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__or2_1
XFILLER_149_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07252_ net1671 net270 net460 VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__mux2_1
XFILLER_118_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07183_ net1356 net265 net469 VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__mux2_1
XFILLER_117_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06203_ reg_pc\[18\] _02648_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__xor2_1
XFILLER_118_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06134_ net492 net1744 net477 VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__mux2_1
XFILLER_144_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06065_ net896 _02534_ net660 VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__a21oi_1
X_05016_ net717 _01635_ VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__and2_1
Xfanout403 _04802_ VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__buf_4
Xfanout414 net417 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkbuf_8
X_09824_ net262 net1689 net352 VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__mux2_1
XFILLER_113_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout447 net448 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__clkbuf_8
Xfanout436 net437 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_6_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout425 _03580_ VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__buf_4
Xfanout469 _03562_ VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout458 net459 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__clkbuf_8
X_09755_ net272 net1979 net359 VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__mux2_1
X_06967_ _03277_ _03300_ _03376_ _03377_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__o31a_1
XFILLER_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06898_ net653 _03311_ VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__or2_1
X_05918_ _02099_ _02462_ _02222_ VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__a21o_1
X_09686_ net2066 net283 net367 VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_87_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08706_ cpuregs\[0\]\[12\] cpuregs\[1\]\[12\] cpuregs\[2\]\[12\] cpuregs\[3\]\[12\]
+ net946 net911 VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__mux4_1
XFILLER_54_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05849_ _02055_ net582 _02406_ _02056_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__o22a_1
XFILLER_104_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08637_ _04318_ _04319_ net671 VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__mux2_1
XFILLER_15_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08568_ cpuregs\[28\]\[5\] cpuregs\[29\]\[5\] cpuregs\[30\]\[5\] cpuregs\[31\]\[5\]
+ net944 net909 VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__mux4_1
XFILLER_42_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07519_ net1604 net263 net428 VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__mux2_1
X_08499_ net83 net1191 net409 VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__mux2_1
XFILLER_22_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_118_2221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10530_ clknet_leaf_134_clk _00654_ VGND VGND VPWR VPWR reg_pc\[10\] sky130_fd_sc_hd__dfxtp_2
X_10461_ clknet_leaf_109_clk _00585_ VGND VGND VPWR VPWR count_instr\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_131_2432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_2421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10392_ clknet_leaf_138_clk _00516_ VGND VGND VPWR VPWR cpuregs\[20\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_150_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_358 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold490 cpuregs\[22\]\[1\] VGND VGND VPWR VPWR net1598 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11013_ clknet_leaf_151_clk _01069_ VGND VGND VPWR VPWR cpuregs\[19\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xfanout970 net971 VGND VGND VPWR VPWR net970 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_129_2394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout992 net994 VGND VGND VPWR VPWR net992 sky130_fd_sc_hd__clkbuf_2
XFILLER_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout981 net982 VGND VGND VPWR VPWR net981 sky130_fd_sc_hd__clkbuf_2
XFILLER_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1190 count_cycle\[10\] VGND VGND VPWR VPWR net2298 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_72_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10728_ clknet_leaf_17_clk _00819_ VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dfxtp_2
Xclkload13 clknet_4_15_0_clk VGND VGND VPWR VPWR clkload13/Y sky130_fd_sc_hd__inv_8
Xclkload24 clknet_leaf_10_clk VGND VGND VPWR VPWR clkload24/Y sky130_fd_sc_hd__clkinvlp_4
X_10659_ clknet_leaf_134_clk _04883_ VGND VGND VPWR VPWR reg_out\[11\] sky130_fd_sc_hd__dfxtp_1
Xclkload35 clknet_leaf_144_clk VGND VGND VPWR VPWR clkload35/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload68 clknet_leaf_52_clk VGND VGND VPWR VPWR clkload68/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload57 clknet_leaf_32_clk VGND VGND VPWR VPWR clkload57/Y sky130_fd_sc_hd__inv_6
Xclkload46 clknet_leaf_136_clk VGND VGND VPWR VPWR clkload46/Y sky130_fd_sc_hd__inv_12
Xclkload79 clknet_leaf_47_clk VGND VGND VPWR VPWR clkload79/Y sky130_fd_sc_hd__bufinv_16
XFILLER_141_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_149_2715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07870_ reg_pc\[17\] net504 _03713_ net604 VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__a22o_1
X_06821_ _03230_ _03231_ net651 VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__mux2_1
XFILLER_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06752_ _03167_ _03170_ VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_69_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09540_ net1481 net471 net381 VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05703_ _02172_ _02277_ VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__or2_1
X_09471_ net1845 net528 net390 VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__mux2_1
XFILLER_37_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08422_ _04160_ net1000 _04159_ VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__and3b_1
X_06683_ cpuregs\[4\]\[13\] cpuregs\[5\]\[13\] cpuregs\[6\]\[13\] cpuregs\[7\]\[13\]
+ net780 net744 VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__mux4_1
XFILLER_52_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05634_ net218 net859 VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_82_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05565_ _02143_ _02144_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__nand2_1
X_08353_ count_cycle\[34\] _04115_ net980 VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__o21ai_1
XFILLER_149_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08284_ count_cycle\[7\] count_cycle\[8\] _04070_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__and3_1
X_07304_ net1994 net329 net450 VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__mux2_1
X_05496_ _02073_ _02075_ VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__nand2_1
X_07235_ net1391 net472 net458 VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__mux2_1
Xclkload7 clknet_4_8_0_clk VGND VGND VPWR VPWR clkload7/Y sky130_fd_sc_hd__clkinvlp_4
X_07166_ net1840 net342 net466 VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__mux2_1
X_07097_ _03496_ _03497_ net655 VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__mux2_1
XFILLER_133_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_113_2140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06117_ net565 _02583_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__and2b_1
XFILLER_133_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06048_ cpuregs\[4\]\[2\] cpuregs\[5\]\[2\] cpuregs\[6\]\[2\] cpuregs\[7\]\[2\] net955
+ net920 VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__mux4_1
XFILLER_114_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout255 _02687_ VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_2
Xfanout244 _02700_ VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__buf_1
XFILLER_99_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout266 _02679_ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout277 _02666_ VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_2
Xfanout288 _02653_ VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__clkbuf_1
XFILLER_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout299 net302 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__clkbuf_2
X_07999_ _03817_ _03818_ VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__xnor2_1
X_09807_ net337 net1818 net349 VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__mux2_1
X_09738_ net473 net2097 net357 VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__mux2_1
XFILLER_55_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09669_ net1876 net530 net366 VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__mux2_1
XFILLER_27_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_145_Right_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10513_ clknet_leaf_82_clk _00637_ VGND VGND VPWR VPWR count_instr\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11493_ clknet_leaf_36_clk _01531_ VGND VGND VPWR VPWR cpuregs\[10\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10444_ clknet_leaf_34_clk _00568_ VGND VGND VPWR VPWR cpuregs\[17\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10375_ clknet_leaf_17_clk _00499_ VGND VGND VPWR VPWR cpuregs\[25\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_144_2634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_80_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05350_ _01924_ _01928_ _01925_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_16_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05281_ count_instr\[49\] net817 net821 count_instr\[17\] VGND VGND VPWR VPWR _01876_
+ sky130_fd_sc_hd__a22o_1
Xclkload113 clknet_leaf_105_clk VGND VGND VPWR VPWR clkload113/Y sky130_fd_sc_hd__clkinv_2
Xclkload102 clknet_leaf_114_clk VGND VGND VPWR VPWR clkload102/Y sky130_fd_sc_hd__inv_6
Xclkload124 clknet_leaf_66_clk VGND VGND VPWR VPWR clkload124/Y sky130_fd_sc_hd__inv_8
Xclkload146 clknet_leaf_90_clk VGND VGND VPWR VPWR clkload146/X sky130_fd_sc_hd__clkbuf_8
X_07020_ decoded_imm\[26\] net856 VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__or2_1
Xclkload135 clknet_leaf_84_clk VGND VGND VPWR VPWR clkload135/Y sky130_fd_sc_hd__bufinv_16
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08971_ decoded_imm\[26\] net599 net628 VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__a21o_1
XFILLER_102_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold19 cpuregs\[0\]\[5\] VGND VGND VPWR VPWR net1127 sky130_fd_sc_hd__dlygate4sd3_1
X_07922_ decoded_imm_j\[4\] _03700_ VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__or2_1
XFILLER_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07853_ _02613_ reg_next_pc\[9\] net569 VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__mux2_2
XFILLER_84_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06804_ _03168_ _03195_ _03193_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__o21ai_1
XFILLER_68_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07784_ _03662_ _03663_ VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__nor2_1
X_04996_ net1147 _01617_ _01620_ VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09523_ net1528 net273 net387 VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__mux2_1
X_06735_ _03149_ _03150_ net647 VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__mux2_1
XFILLER_37_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09454_ net286 net1541 net394 VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__mux2_1
X_06666_ net524 _03071_ _03072_ _03074_ _03088_ VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__o41a_1
XFILLER_52_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08405_ count_cycle\[52\] count_cycle\[53\] _04146_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__and3_1
X_05617_ net204 net875 VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__nand2b_1
X_09385_ net834 decoded_imm_j\[6\] _04826_ mem_rdata_q\[26\] net551 VGND VGND VPWR
+ VPWR _04855_ sky130_fd_sc_hd__a221o_1
X_08336_ _04105_ _04106_ VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__nor2_1
X_06597_ cpuregs\[8\]\[10\] cpuregs\[9\]\[10\] cpuregs\[10\]\[10\] cpuregs\[11\]\[10\]
+ net782 net746 VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_49_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05548_ net883 net846 VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__or2_1
XFILLER_137_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05479_ _02054_ _02058_ VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_140_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_140_clk sky130_fd_sc_hd__clkbuf_8
X_08267_ count_cycle\[0\] count_cycle\[1\] count_cycle\[2\] VGND VGND VPWR VPWR _04063_
+ sky130_fd_sc_hd__a21o_1
XFILLER_153_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07218_ net1843 net269 net464 VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__mux2_1
X_08198_ _03989_ _03993_ _04001_ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07149_ net736 _03547_ net730 VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_95_1854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10160_ clknet_leaf_57_clk _00284_ VGND VGND VPWR VPWR cpuregs\[21\]\[24\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_58_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10091_ clknet_leaf_22_clk _00215_ VGND VGND VPWR VPWR cpuregs\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_126_2342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_908 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10993_ clknet_leaf_20_clk _01049_ VGND VGND VPWR VPWR cpuregs\[18\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_67_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11614_ net122 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_13_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_131_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_131_clk sky130_fd_sc_hd__clkbuf_8
X_11476_ clknet_leaf_142_clk _01514_ VGND VGND VPWR VPWR cpuregs\[10\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10427_ clknet_leaf_123_clk _00551_ VGND VGND VPWR VPWR cpuregs\[17\]\[3\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_76_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10358_ clknet_leaf_63_clk _00482_ VGND VGND VPWR VPWR cpuregs\[16\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_10289_ clknet_leaf_49_clk _00413_ VGND VGND VPWR VPWR cpuregs\[15\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_49_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06520_ cpuregs\[0\]\[7\] cpuregs\[1\]\[7\] cpuregs\[2\]\[7\] cpuregs\[3\]\[7\] net774
+ net738 VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__mux4_1
Xpicorv32_1107 VGND VGND VPWR VPWR picorv32_1107/HI trace_data[35] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_62_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06451_ _02866_ _02878_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__or2_1
X_05402_ _01985_ _01986_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__nand2_1
XFILLER_61_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09170_ mem_rdata_q\[23\] mem_rdata_q\[22\] mem_rdata_q\[21\] _04784_ VGND VGND VPWR
+ VPWR _04785_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_32_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06382_ net883 net305 _02803_ _02814_ VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__o22a_1
XFILLER_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05333_ _01918_ _01922_ _01923_ VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__or3_1
X_08121_ _03930_ _03931_ net991 VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__o21a_1
Xclkbuf_leaf_122_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_122_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_30_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05264_ reg_pc\[16\] decoded_imm\[16\] VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__nand2_1
X_08052_ net689 reg_next_pc\[14\] net546 _03710_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__a22o_1
XFILLER_135_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07003_ cpuregs\[24\]\[25\] cpuregs\[25\]\[25\] cpuregs\[26\]\[25\] cpuregs\[27\]\[25\]
+ net804 net767 VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__mux4_1
XFILLER_127_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05195_ _01760_ _01795_ net701 VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__o21a_1
XFILLER_143_762 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08954_ cpuregs\[24\]\[26\] cpuregs\[25\]\[26\] cpuregs\[26\]\[26\] cpuregs\[27\]\[26\]
+ net969 net934 VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__mux4_1
XFILLER_102_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07905_ decoded_imm_j\[2\] _03697_ VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__and2_1
X_08885_ net903 _04561_ VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__or2_1
XFILLER_57_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_108_2061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07836_ net603 _03695_ VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__and2_1
XFILLER_112_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_04979_ mem_do_prefetch _01603_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__and2_1
XFILLER_16_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07767_ net2336 _03651_ net981 VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__o21ai_1
X_06718_ decoded_imm\[15\] net871 VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__or2_1
X_09506_ net1407 net475 net385 VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__mux2_1
XFILLER_37_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_121_2272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07698_ net2259 _03607_ net988 VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__o21ai_1
X_06649_ net173 net507 _02993_ net495 VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__o211a_1
XFILLER_9_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09437_ net531 net1992 net396 VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__mux2_1
X_09368_ net836 decoded_imm_j\[14\] net615 net719 VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__a22o_1
XFILLER_12_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09299_ net1190 net113 net485 VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__mux2_1
X_08319_ net2293 _04094_ net993 VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__o21ai_1
XANTENNA_60 net223 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_82 net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11330_ clknet_leaf_38_clk _01371_ VGND VGND VPWR VPWR cpuregs\[5\]\[21\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_71 net443 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_93 net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_138_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11261_ clknet_leaf_44_clk _01302_ VGND VGND VPWR VPWR cpuregs\[22\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10212_ clknet_leaf_7_clk _00336_ VGND VGND VPWR VPWR cpuregs\[14\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_11192_ clknet_leaf_3_clk _01233_ VGND VGND VPWR VPWR cpuregs\[29\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_10143_ clknet_leaf_152_clk _00267_ VGND VGND VPWR VPWR cpuregs\[21\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10074_ clknet_leaf_121_clk _00198_ VGND VGND VPWR VPWR cpuregs\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10976_ clknet_leaf_120_clk _01032_ VGND VGND VPWR VPWR cpuregs\[18\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_43_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_139_2555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_104_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_104_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_117_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_2766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold308 _00002_ VGND VGND VPWR VPWR net1416 sky130_fd_sc_hd__dlygate4sd3_1
Xhold319 cpuregs\[23\]\[27\] VGND VGND VPWR VPWR net1427 sky130_fd_sc_hd__dlygate4sd3_1
X_11459_ clknet_leaf_23_clk _01497_ VGND VGND VPWR VPWR cpuregs\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1008 cpuregs\[7\]\[28\] VGND VGND VPWR VPWR net2116 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1019 cpuregs\[10\]\[21\] VGND VGND VPWR VPWR net2127 sky130_fd_sc_hd__dlygate4sd3_1
X_05951_ net845 net216 net594 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_72_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05882_ _02433_ _02435_ net693 VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__mux2_1
X_08670_ net673 _04358_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__or2_1
X_07621_ net1498 net259 net416 VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__mux2_1
XFILLER_81_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07552_ net267 net2202 net423 VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__mux2_1
X_06503_ reg_pc\[6\] net560 _02931_ net516 net520 VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__a221o_1
X_07483_ net1684 net277 net432 VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__mux2_1
X_09222_ net2078 net556 _04801_ VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__o21a_1
X_06434_ decoded_imm\[4\] net881 VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_79_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09153_ net2247 net501 _04752_ _04773_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__a22o_1
X_06365_ net650 _02795_ _02797_ VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__a21o_1
XFILLER_108_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08104_ _03912_ _03913_ _03914_ _03915_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__o22a_1
X_05316_ count_instr\[52\] net818 net822 count_instr\[20\] VGND VGND VPWR VPWR _01908_
+ sky130_fd_sc_hd__a22o_1
X_09084_ mem_rdata_q\[5\] _01599_ _04740_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__a21oi_2
X_06296_ net717 net707 VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_92_1802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08035_ _03816_ _03826_ _03849_ _03851_ VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__a31o_1
X_05247_ latched_is_lb latched_is_lh VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__or2_2
Xhold820 cpuregs\[16\]\[2\] VGND VGND VPWR VPWR net1928 sky130_fd_sc_hd__dlygate4sd3_1
Xhold831 cpuregs\[22\]\[23\] VGND VGND VPWR VPWR net1939 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_784 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold853 cpuregs\[12\]\[14\] VGND VGND VPWR VPWR net1961 sky130_fd_sc_hd__dlygate4sd3_1
X_05178_ reg_pc\[10\] decoded_imm\[10\] VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__nand2_1
Xhold842 cpuregs\[25\]\[9\] VGND VGND VPWR VPWR net1950 sky130_fd_sc_hd__dlygate4sd3_1
Xhold864 cpuregs\[29\]\[5\] VGND VGND VPWR VPWR net1972 sky130_fd_sc_hd__dlygate4sd3_1
Xhold897 cpuregs\[24\]\[22\] VGND VGND VPWR VPWR net2005 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_130_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_294 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold875 cpuregs\[8\]\[14\] VGND VGND VPWR VPWR net1983 sky130_fd_sc_hd__dlygate4sd3_1
Xhold886 cpuregs\[28\]\[9\] VGND VGND VPWR VPWR net1994 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_130_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09986_ clknet_leaf_15_clk _00110_ VGND VGND VPWR VPWR cpuregs\[12\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_08937_ cpuregs\[20\]\[25\] cpuregs\[21\]\[25\] cpuregs\[22\]\[25\] cpuregs\[23\]\[25\]
+ net969 net934 VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__mux4_1
XFILLER_103_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08868_ cpuregs\[0\]\[21\] cpuregs\[1\]\[21\] cpuregs\[2\]\[21\] cpuregs\[3\]\[21\]
+ net963 net928 VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__mux4_1
XFILLER_85_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_123_2301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07819_ count_instr\[57\] _03682_ count_instr\[58\] VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_4_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08799_ cpuregs\[16\]\[17\] cpuregs\[17\]\[17\] cpuregs\[18\]\[17\] cpuregs\[19\]\[17\]
+ net958 net923 VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__mux4_1
XFILLER_84_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10830_ clknet_leaf_131_clk _00889_ VGND VGND VPWR VPWR decoded_imm_j\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10761_ clknet_leaf_135_clk alu_out\[8\] VGND VGND VPWR VPWR alu_out_q\[8\] sky130_fd_sc_hd__dfxtp_1
X_10692_ clknet_leaf_68_clk _00784_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_148_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_2474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11313_ clknet_leaf_126_clk _01354_ VGND VGND VPWR VPWR cpuregs\[5\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11244_ clknet_leaf_24_clk _01285_ VGND VGND VPWR VPWR cpuregs\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11175_ clknet_leaf_45_clk _01216_ VGND VGND VPWR VPWR cpuregs\[23\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_68_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10126_ clknet_leaf_42_clk _00250_ VGND VGND VPWR VPWR cpuregs\[28\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_10057_ clknet_leaf_25_clk _00181_ VGND VGND VPWR VPWR cpuregs\[13\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_546 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_387 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10959_ clknet_leaf_94_clk _01015_ VGND VGND VPWR VPWR decoded_imm\[15\] sky130_fd_sc_hd__dfxtp_2
XFILLER_148_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06150_ net340 net1964 net476 VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__mux2_1
Xhold105 net47 VGND VGND VPWR VPWR net1213 sky130_fd_sc_hd__dlygate4sd3_1
X_05101_ net887 net698 _01708_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__and3_1
X_06081_ _02548_ _02549_ net674 VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__mux2_1
Xhold116 cpuregs\[23\]\[9\] VGND VGND VPWR VPWR net1224 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 cpuregs\[12\]\[29\] VGND VGND VPWR VPWR net1235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 cpuregs\[29\]\[24\] VGND VGND VPWR VPWR net1246 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold149 cpuregs\[1\]\[15\] VGND VGND VPWR VPWR net1257 sky130_fd_sc_hd__dlygate4sd3_1
X_05032_ net717 is_sll_srl_sra net601 _01642_ _01646_ VGND VGND VPWR VPWR _01648_
+ sky130_fd_sc_hd__a41o_1
Xfanout607 net608 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__clkbuf_4
Xfanout618 net620 VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout629 _01574_ VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__buf_2
X_09840_ net338 net2045 net345 VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__mux2_1
X_06983_ cpuregs\[20\]\[24\] cpuregs\[21\]\[24\] cpuregs\[22\]\[24\] cpuregs\[23\]\[24\]
+ net796 net758 VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__mux4_1
XFILLER_112_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09771_ net473 net1922 net353 VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__mux2_1
XFILLER_79_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05934_ net697 net846 net204 net694 VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__a22o_1
X_08722_ net900 _04407_ VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_13_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_340 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05865_ _02419_ _02420_ net829 VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08653_ net669 _04333_ net889 VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__o21a_1
X_05796_ _02113_ _02358_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__nand2_1
X_08584_ decoded_imm\[5\] net600 net626 VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__a21o_1
X_07604_ net1780 net338 net414 VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_85_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07535_ net470 net2047 net422 VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__mux2_1
X_07466_ net1433 net492 net431 VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_22_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06417_ net649 _02847_ net641 VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__a21o_1
X_09205_ net1249 net32 net612 VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__mux2_1
X_07397_ net1295 net532 net439 VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__mux2_1
XFILLER_147_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09136_ net1716 net499 _04767_ _04768_ VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_20_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06348_ _02779_ _02780_ _02741_ VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__a21boi_1
XFILLER_135_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06279_ cpuregs\[8\]\[0\] cpuregs\[9\]\[0\] cpuregs\[10\]\[0\] cpuregs\[11\]\[0\]
+ net782 net746 VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__mux4_1
X_09067_ latched_store _04732_ _04733_ net978 VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_116_2193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08018_ decoded_imm_j\[12\] _03708_ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__xor2_1
Xhold661 cpuregs\[5\]\[27\] VGND VGND VPWR VPWR net1769 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold650 cpuregs\[22\]\[20\] VGND VGND VPWR VPWR net1758 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold672 cpuregs\[20\]\[8\] VGND VGND VPWR VPWR net1780 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold694 cpuregs\[9\]\[29\] VGND VGND VPWR VPWR net1802 sky130_fd_sc_hd__dlygate4sd3_1
Xhold683 cpuregs\[25\]\[27\] VGND VGND VPWR VPWR net1791 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_31_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09969_ clknet_leaf_60_clk _00093_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dfxtp_2
XFILLER_89_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_150_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10813_ clknet_leaf_98_clk _00872_ VGND VGND VPWR VPWR instr_sll sky130_fd_sc_hd__dfxtp_1
XFILLER_60_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_40_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_136_2503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10744_ clknet_leaf_63_clk _00835_ VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dfxtp_4
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_136_2514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10675_ clknet_leaf_63_clk _04900_ VGND VGND VPWR VPWR reg_out\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11227_ clknet_leaf_29_clk _01268_ VGND VGND VPWR VPWR cpuregs\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_150_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11158_ clknet_leaf_0_clk _01199_ VGND VGND VPWR VPWR cpuregs\[23\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_95_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_52_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10109_ clknet_leaf_141_clk _00233_ VGND VGND VPWR VPWR cpuregs\[28\]\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_147_2687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11089_ clknet_leaf_11_clk _01140_ VGND VGND VPWR VPWR cpuregs\[24\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_822 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05650_ _02104_ _02229_ _02228_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__a21o_1
XFILLER_64_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05581_ net881 net123 VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__and2_1
XFILLER_23_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07320_ net1443 net260 net452 VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__mux2_1
XFILLER_16_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07251_ net1608 net273 net460 VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__mux2_1
XFILLER_31_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07182_ net1516 net270 net468 VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__mux2_1
XFILLER_136_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_118_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06202_ reg_out\[18\] alu_out_q\[18\] net842 VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__mux2_1
X_06133_ _02592_ _02595_ net565 VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__mux2_1
XFILLER_117_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06064_ _02532_ _02533_ net675 VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__mux2_1
Xfanout404 net405 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__clkbuf_8
X_05015_ _01593_ _01594_ net984 VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__nor3b_2
Xfanout437 _03576_ VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__buf_4
X_09823_ net265 net2018 net351 VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__mux2_1
Xfanout448 net449 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__clkbuf_8
XFILLER_99_796 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout415 net416 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__clkbuf_8
XFILLER_86_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout426 net427 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__clkbuf_8
Xfanout459 _03568_ VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__buf_4
X_09754_ net275 net1849 net359 VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__mux2_1
X_06966_ _03325_ _03350_ _03376_ _03328_ _03352_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__o221a_1
XFILLER_67_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06897_ cpuregs\[28\]\[21\] cpuregs\[29\]\[21\] cpuregs\[30\]\[21\] cpuregs\[31\]\[21\]
+ net798 net761 VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__mux4_1
X_09685_ net1657 net287 net367 VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__mux2_1
X_05917_ _02098_ _02465_ _02466_ VGND VGND VPWR VPWR alu_out\[30\] sky130_fd_sc_hd__o21ai_1
XFILLER_104_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_87_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08705_ cpuregs\[4\]\[12\] cpuregs\[5\]\[12\] cpuregs\[6\]\[12\] cpuregs\[7\]\[12\]
+ net946 net911 VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05848_ _02055_ net576 net585 VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_leaf_93_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_93_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_15_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08636_ _04317_ _04325_ _04326_ net658 net895 VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__a221o_1
XFILLER_82_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05779_ _02343_ _02344_ net828 VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__mux2_1
X_08567_ cpuregs\[16\]\[5\] cpuregs\[17\]\[5\] cpuregs\[18\]\[5\] cpuregs\[19\]\[5\]
+ net944 net909 VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_25_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08498_ net82 net1200 net408 VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__mux2_1
X_07518_ net1564 net269 net428 VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__mux2_1
XFILLER_23_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07449_ net1459 net281 net436 VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__mux2_1
X_10460_ clknet_leaf_109_clk _00584_ VGND VGND VPWR VPWR count_instr\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_129_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09119_ net2205 net548 _04760_ is_lb_lh_lw_lbu_lhu VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__a22o_1
XFILLER_136_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_131_2433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_2422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10391_ clknet_leaf_55_clk _00515_ VGND VGND VPWR VPWR cpuregs\[25\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_98_1896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold480 cpuregs\[17\]\[24\] VGND VGND VPWR VPWR net1588 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold491 cpuregs\[4\]\[24\] VGND VGND VPWR VPWR net1599 sky130_fd_sc_hd__dlygate4sd3_1
X_11012_ clknet_leaf_148_clk _01068_ VGND VGND VPWR VPWR cpuregs\[19\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xfanout960 net968 VGND VGND VPWR VPWR net960 sky130_fd_sc_hd__clkbuf_4
Xfanout971 net975 VGND VGND VPWR VPWR net971 sky130_fd_sc_hd__clkbuf_4
Xfanout993 net994 VGND VGND VPWR VPWR net993 sky130_fd_sc_hd__buf_1
XFILLER_64_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout982 net983 VGND VGND VPWR VPWR net982 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_129_2395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1191 count_instr\[59\] VGND VGND VPWR VPWR net2299 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_84_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_84_clk sky130_fd_sc_hd__clkbuf_8
Xhold1180 count_cycle\[43\] VGND VGND VPWR VPWR net2288 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_72_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10727_ clknet_leaf_17_clk _00818_ VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dfxtp_2
XFILLER_9_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload25 clknet_leaf_11_clk VGND VGND VPWR VPWR clkload25/Y sky130_fd_sc_hd__bufinv_16
X_10658_ clknet_leaf_133_clk _04882_ VGND VGND VPWR VPWR reg_out\[10\] sky130_fd_sc_hd__dfxtp_1
Xclkload14 clknet_leaf_0_clk VGND VGND VPWR VPWR clkload14/Y sky130_fd_sc_hd__clkinv_4
Xclkload69 clknet_leaf_54_clk VGND VGND VPWR VPWR clkload69/Y sky130_fd_sc_hd__inv_4
Xclkload58 clknet_leaf_34_clk VGND VGND VPWR VPWR clkload58/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload36 clknet_leaf_145_clk VGND VGND VPWR VPWR clkload36/Y sky130_fd_sc_hd__inv_6
X_10589_ clknet_leaf_108_clk _00713_ VGND VGND VPWR VPWR count_cycle\[6\] sky130_fd_sc_hd__dfxtp_1
Xclkload47 clknet_leaf_137_clk VGND VGND VPWR VPWR clkload47/Y sky130_fd_sc_hd__clkinv_4
XTAP_TAPCELL_ROW_149_2716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06820_ _03232_ _03233_ net651 VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__mux2_1
XFILLER_49_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06751_ _03168_ _03169_ VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_69_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_75_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_75_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_69_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06682_ cpuregs\[24\]\[13\] cpuregs\[25\]\[13\] cpuregs\[26\]\[13\] cpuregs\[27\]\[13\]
+ net780 net744 VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__mux4_1
X_05702_ _02189_ _02276_ net692 VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__mux2_1
X_09470_ net1798 net533 net390 VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__mux2_1
XFILLER_36_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08421_ count_cycle\[58\] count_cycle\[59\] _04157_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__and3_1
XFILLER_52_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05633_ net217 net861 VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_82_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05564_ net886 net108 VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__nand2_1
X_08352_ _04115_ _04116_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__nor2_1
XFILLER_149_245 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05495_ net867 net212 VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__or2_1
XFILLER_60_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08283_ count_cycle\[7\] _04070_ count_cycle\[8\] VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__a21o_1
X_07303_ net1637 net337 net450 VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__mux2_1
XFILLER_32_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07234_ net1296 net475 net458 VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__mux2_1
Xclkload8 clknet_4_9_0_clk VGND VGND VPWR VPWR clkload8/Y sky130_fd_sc_hd__inv_8
XFILLER_118_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07165_ net1749 net472 net466 VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__mux2_1
X_07096_ cpuregs\[24\]\[28\] cpuregs\[25\]\[28\] cpuregs\[26\]\[28\] cpuregs\[27\]\[28\]
+ net806 net769 VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__mux4_1
XFILLER_132_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_2141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06116_ reg_out\[0\] alu_out_q\[0\] net840 VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__mux2_1
XFILLER_132_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06047_ _01623_ _01626_ net705 VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__o21ai_1
XFILLER_120_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__clkbuf_2
Xfanout256 _02687_ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__buf_1
XFILLER_114_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout267 _02674_ VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_2
Xfanout278 _02666_ VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout289 _02653_ VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__clkbuf_2
XFILLER_87_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_86_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07998_ _03803_ _03809_ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__or2_1
X_09806_ net342 net2038 net349 VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__mux2_1
X_06949_ cpuregs\[24\]\[23\] cpuregs\[25\]\[23\] cpuregs\[26\]\[23\] cpuregs\[27\]\[23\]
+ net800 net763 VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__mux4_1
X_09737_ net494 net1956 net358 VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__mux2_1
XFILLER_28_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_66_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_66_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_131_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09668_ net1374 net536 net366 VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__mux2_1
XFILLER_82_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08619_ net899 _04306_ _04305_ net658 VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__o211a_1
X_09599_ _02580_ _03560_ VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__or2_4
XFILLER_145_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10512_ clknet_leaf_83_clk _00636_ VGND VGND VPWR VPWR count_instr\[55\] sky130_fd_sc_hd__dfxtp_1
X_11492_ clknet_leaf_33_clk _01530_ VGND VGND VPWR VPWR cpuregs\[10\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10443_ clknet_leaf_20_clk _00567_ VGND VGND VPWR VPWR cpuregs\[17\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10374_ clknet_leaf_11_clk _00498_ VGND VGND VPWR VPWR cpuregs\[25\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_2635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout790 net809 VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__buf_2
Xclkbuf_leaf_57_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_57_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_92_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05280_ net9 net597 net587 VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__a21o_1
Xclkload103 clknet_leaf_115_clk VGND VGND VPWR VPWR clkload103/Y sky130_fd_sc_hd__clkinv_8
XFILLER_146_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload125 clknet_leaf_67_clk VGND VGND VPWR VPWR clkload125/Y sky130_fd_sc_hd__inv_8
Xclkload136 clknet_leaf_85_clk VGND VGND VPWR VPWR clkload136/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload114 clknet_leaf_106_clk VGND VGND VPWR VPWR clkload114/Y sky130_fd_sc_hd__inv_6
XFILLER_6_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08970_ _04640_ _04642_ net481 _04639_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__o211a_1
XFILLER_111_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07921_ _03740_ _03741_ _03738_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__o21ai_1
XFILLER_110_351 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_906 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07852_ net2379 net502 _03704_ net602 VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__a22o_1
X_06803_ _03218_ _03219_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__nor2_1
Xinput1 mem_rdata[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
Xclkbuf_leaf_48_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_48_clk sky130_fd_sc_hd__clkbuf_8
X_09522_ net1677 net278 net387 VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__mux2_1
X_07783_ net2320 _03661_ net988 VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__o21ai_1
X_04995_ instr_sw _01606_ _01619_ instr_lw net603 VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__a221o_1
X_06734_ cpuregs\[24\]\[15\] cpuregs\[25\]\[15\] cpuregs\[26\]\[15\] cpuregs\[27\]\[15\]
+ net783 net747 VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__mux4_1
X_09453_ net288 net1908 net394 VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__mux2_1
XFILLER_92_791 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06665_ reg_pc\[12\] net560 _03087_ net516 net520 VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__a221o_1
XFILLER_64_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08404_ count_cycle\[52\] _04146_ count_cycle\[53\] VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__a21o_1
X_05616_ _01559_ net205 VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__or2_1
X_09384_ net2372 net552 _04854_ VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__o21a_1
X_08335_ net2243 _04104_ net992 VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__o21ai_1
X_06596_ cpuregs\[12\]\[10\] cpuregs\[13\]\[10\] cpuregs\[14\]\[10\] cpuregs\[15\]\[10\]
+ net783 net747 VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__mux4_1
XFILLER_51_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_35_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05547_ net883 net846 VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__nor2_1
X_05478_ _02055_ _02057_ VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__nand2_2
X_08266_ net2338 count_cycle\[1\] _04062_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__a21oi_1
X_07217_ net1759 net273 net463 VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__mux2_1
X_08197_ _03999_ _04000_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__nor2_1
X_07148_ _03550_ _03551_ net655 VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_95_1855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_145_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07079_ decoded_imm\[28\] net854 VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__or2_1
XFILLER_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10090_ clknet_leaf_32_clk _00214_ VGND VGND VPWR VPWR cpuregs\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_102_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_39_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_39_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_126_2354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10992_ clknet_leaf_31_clk _01048_ VGND VGND VPWR VPWR cpuregs\[18\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11613_ net846 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_1
XFILLER_31_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_128_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11475_ clknet_leaf_126_clk _01513_ VGND VGND VPWR VPWR cpuregs\[10\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_137_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10426_ clknet_leaf_120_clk _00550_ VGND VGND VPWR VPWR cpuregs\[17\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_10357_ clknet_leaf_72_clk _00481_ VGND VGND VPWR VPWR cpuregs\[16\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_817 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10288_ clknet_leaf_51_clk _00412_ VGND VGND VPWR VPWR cpuregs\[15\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06450_ _02832_ _02834_ _02867_ _02878_ VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__a211o_1
X_05401_ reg_pc\[27\] decoded_imm\[27\] VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__nand2_1
XFILLER_61_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xpicorv32_1108 VGND VGND VPWR VPWR picorv32_1108/HI trace_valid sky130_fd_sc_hd__conb_1
XFILLER_21_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06381_ net606 _02807_ _02809_ _02813_ net303 VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__a311o_1
X_08120_ net689 reg_next_pc\[19\] net546 _03716_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__a22o_1
X_05332_ net704 net344 _01919_ net709 net863 VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__a32o_1
XFILLER_30_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05263_ reg_pc\[16\] decoded_imm\[16\] VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__or2_1
X_08051_ _03864_ _03866_ net836 _03863_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_128_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07002_ net863 net511 net490 _03411_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__o211a_1
XFILLER_127_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05194_ net3 _01653_ _01654_ net20 _01761_ VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__o221a_1
XFILLER_143_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08953_ net220 net633 _04625_ _04626_ VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__o22a_1
XFILLER_103_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07904_ net834 _03697_ net848 VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__o21a_1
X_08884_ cpuregs\[24\]\[22\] cpuregs\[25\]\[22\] cpuregs\[26\]\[22\] cpuregs\[27\]\[22\]
+ net968 net933 VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__mux4_1
XFILLER_111_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07835_ _02585_ reg_next_pc\[1\] net571 VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_108_2062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04978_ net978 _01602_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__nand2_1
X_07766_ count_instr\[38\] count_instr\[37\] count_instr\[36\] _03647_ VGND VGND VPWR
+ VPWR _03652_ sky130_fd_sc_hd__and4_1
X_06717_ net176 _03137_ net306 VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__mux2_1
X_09505_ net1337 _02596_ net386 VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_121_2262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07697_ count_instr\[13\] count_instr\[12\] count_instr\[11\] _03603_ VGND VGND VPWR
+ VPWR _03608_ sky130_fd_sc_hd__and4_1
XFILLER_52_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09436_ net534 net2048 net396 VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_121_2273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06648_ _03040_ _03065_ _03066_ _03068_ _03070_ VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__a41oi_1
XFILLER_13_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09367_ net2365 net555 _04827_ _04845_ VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__o22a_1
X_06579_ _02999_ _03000_ net644 VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__mux2_1
X_09298_ net1189 net112 net485 VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__mux2_1
XANTENNA_50 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08318_ count_cycle\[19\] count_cycle\[20\] count_cycle\[21\] _04090_ VGND VGND VPWR
+ VPWR _04095_ sky130_fd_sc_hd__and4_1
XFILLER_138_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_83 net668 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08249_ _03726_ _03727_ _04027_ VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__and3_1
XANTENNA_61 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_72 net443 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_125_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_94 net847 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11260_ clknet_leaf_26_clk _01301_ VGND VGND VPWR VPWR cpuregs\[22\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11191_ clknet_leaf_15_clk _01232_ VGND VGND VPWR VPWR cpuregs\[29\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_10211_ clknet_leaf_5_clk _00335_ VGND VGND VPWR VPWR cpuregs\[14\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_133_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10142_ clknet_leaf_146_clk _00266_ VGND VGND VPWR VPWR cpuregs\[21\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xoutput190 net190 VGND VGND VPWR VPWR pcpi_rs1[27] sky130_fd_sc_hd__buf_2
XFILLER_121_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10073_ clknet_leaf_121_clk _00197_ VGND VGND VPWR VPWR cpuregs\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10975_ clknet_leaf_120_clk _01031_ VGND VGND VPWR VPWR cpuregs\[18\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_44_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_152_2767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_2756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11458_ clknet_leaf_31_clk _01496_ VGND VGND VPWR VPWR cpuregs\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold309 cpuregs\[2\]\[7\] VGND VGND VPWR VPWR net1417 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_125_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10409_ clknet_leaf_27_clk _00533_ VGND VGND VPWR VPWR cpuregs\[20\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_11389_ clknet_leaf_8_clk _01427_ VGND VGND VPWR VPWR cpuregs\[7\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_59_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05950_ net123 net215 net594 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__mux2_1
XFILLER_94_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1009 cpuregs\[18\]\[5\] VGND VGND VPWR VPWR net2117 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05881_ _02089_ _02094_ _02434_ _02093_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__a31o_1
XFILLER_66_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07620_ net1626 net263 net416 VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__mux2_1
XFILLER_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07551_ net271 net1945 net423 VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06502_ _02927_ _02928_ _02929_ _02930_ net726 net722 VGND VGND VPWR VPWR _02931_
+ sky130_fd_sc_hd__mux4_1
X_07482_ net1651 net279 net432 VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__mux2_1
X_09221_ is_alu_reg_imm _04751_ net548 instr_jalr VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__a211o_1
XFILLER_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06433_ reg_pc\[4\] net560 _02863_ net517 net520 VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__a221o_1
X_09152_ net831 net501 _04749_ _04776_ VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__a22o_1
X_06364_ net733 _02796_ net638 VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__a21o_1
XFILLER_147_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08103_ _03715_ _03892_ net836 VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__a21o_1
X_05315_ net13 net596 net588 VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_79_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09083_ net33 net134 net28 VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__and3_1
X_06295_ net726 _02725_ _02729_ VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__a21o_1
Xhold810 cpuregs\[18\]\[22\] VGND VGND VPWR VPWR net1918 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05246_ _01840_ _01841_ _01842_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__a21oi_1
X_08034_ decoded_imm_j\[12\] _03708_ _03850_ VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__o21a_1
Xhold821 cpuregs\[18\]\[7\] VGND VGND VPWR VPWR net1929 sky130_fd_sc_hd__dlygate4sd3_1
Xhold843 cpuregs\[30\]\[16\] VGND VGND VPWR VPWR net1951 sky130_fd_sc_hd__dlygate4sd3_1
Xhold854 cpuregs\[24\]\[17\] VGND VGND VPWR VPWR net1962 sky130_fd_sc_hd__dlygate4sd3_1
Xhold832 cpuregs\[6\]\[14\] VGND VGND VPWR VPWR net1940 sky130_fd_sc_hd__dlygate4sd3_1
X_05177_ reg_pc\[10\] decoded_imm\[10\] VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__or2_1
Xhold887 cpuregs\[6\]\[28\] VGND VGND VPWR VPWR net1995 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold876 cpuregs\[7\]\[22\] VGND VGND VPWR VPWR net1984 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_796 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold898 cpuregs\[7\]\[20\] VGND VGND VPWR VPWR net2006 sky130_fd_sc_hd__dlygate4sd3_1
Xhold865 cpuregs\[11\]\[14\] VGND VGND VPWR VPWR net1973 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_130_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09985_ clknet_leaf_151_clk _00109_ VGND VGND VPWR VPWR cpuregs\[12\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_08936_ cpuregs\[28\]\[25\] cpuregs\[29\]\[25\] cpuregs\[30\]\[25\] cpuregs\[31\]\[25\]
+ net971 net936 VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__mux4_1
XFILLER_123_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08867_ cpuregs\[4\]\[21\] cpuregs\[5\]\[21\] cpuregs\[6\]\[21\] cpuregs\[7\]\[21\]
+ net963 net928 VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_95_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07818_ net2318 _03682_ _03684_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__a21oi_1
XFILLER_85_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08798_ cpuregs\[20\]\[17\] cpuregs\[21\]\[17\] cpuregs\[22\]\[17\] cpuregs\[23\]\[17\]
+ net958 net923 VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__mux4_1
XFILLER_44_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07749_ _03641_ net992 _03640_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__and3b_1
XFILLER_37_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10760_ clknet_leaf_137_clk alu_out\[7\] VGND VGND VPWR VPWR alu_out_q\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09419_ net291 net1865 net398 VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__mux2_1
X_10691_ clknet_leaf_84_clk _00783_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfxtp_1
XFILLER_139_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_134_2475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11312_ clknet_leaf_124_clk _01353_ VGND VGND VPWR VPWR cpuregs\[5\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11243_ clknet_leaf_74_clk _01284_ VGND VGND VPWR VPWR cpuregs\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11174_ clknet_leaf_51_clk _01215_ VGND VGND VPWR VPWR cpuregs\[23\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10125_ clknet_leaf_44_clk _00249_ VGND VGND VPWR VPWR cpuregs\[28\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10056_ clknet_leaf_55_clk _00180_ VGND VGND VPWR VPWR cpuregs\[13\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10958_ clknet_leaf_93_clk _01014_ VGND VGND VPWR VPWR decoded_imm\[16\] sky130_fd_sc_hd__dfxtp_2
XFILLER_31_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10889_ clknet_leaf_70_clk _00945_ VGND VGND VPWR VPWR cpuregs\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_117_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold117 net42 VGND VGND VPWR VPWR net1225 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05100_ net4 net21 net885 VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__mux2_1
Xhold106 is_slli_srli_srai VGND VGND VPWR VPWR net1214 sky130_fd_sc_hd__dlygate4sd3_1
X_06080_ cpuregs\[16\]\[3\] cpuregs\[17\]\[3\] cpuregs\[18\]\[3\] cpuregs\[19\]\[3\]
+ net953 net918 VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__mux4_1
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold128 cpuregs\[1\]\[13\] VGND VGND VPWR VPWR net1236 sky130_fd_sc_hd__dlygate4sd3_1
X_05031_ _01623_ _01625_ _01554_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold139 cpuregs\[25\]\[3\] VGND VGND VPWR VPWR net1247 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout619 net620 VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout608 _01613_ VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__clkbuf_4
X_06982_ cpuregs\[0\]\[24\] cpuregs\[1\]\[24\] cpuregs\[2\]\[24\] cpuregs\[3\]\[24\]
+ net801 net764 VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09770_ net494 net2119 net354 VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__mux2_1
XFILLER_100_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08721_ cpuregs\[0\]\[13\] cpuregs\[1\]\[13\] cpuregs\[2\]\[13\] cpuregs\[3\]\[13\]
+ net948 net913 VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__mux4_1
X_05933_ net696 net108 net234 net593 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__a22o_1
XFILLER_39_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08652_ cpuregs\[8\]\[9\] cpuregs\[9\]\[9\] cpuregs\[10\]\[9\] cpuregs\[11\]\[9\]
+ net941 net906 VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_105_2010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05864_ _02078_ _02115_ _02206_ _02221_ VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__o31ai_2
X_07603_ net1820 net339 net414 VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05795_ _02113_ _02358_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__or2_1
XFILLER_81_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08583_ _04275_ _04276_ net482 _04273_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_85_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07534_ net473 net1981 net422 VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_85_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07465_ net1526 net529 net431 VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__mux2_1
X_06416_ cpuregs\[24\]\[4\] cpuregs\[25\]\[4\] cpuregs\[26\]\[4\] cpuregs\[27\]\[4\]
+ net787 net751 VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__mux4_1
X_09204_ net1188 _01102_ net330 VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__mux2_1
X_07396_ net1301 net534 net439 VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__mux2_1
XFILLER_136_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09135_ net719 net720 net721 VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_20_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06347_ _02741_ _02779_ _02780_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__and3b_1
XFILLER_136_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06278_ net648 _02712_ VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__or2_1
X_09066_ _04730_ net700 _02731_ _04732_ VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__or4bb_1
XFILLER_118_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_116_2194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05229_ net711 _01820_ _01821_ _01827_ VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__a31o_1
X_08017_ _03834_ _03835_ net976 VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__o21a_1
XFILLER_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold662 cpuregs\[28\]\[26\] VGND VGND VPWR VPWR net1770 sky130_fd_sc_hd__dlygate4sd3_1
Xhold651 cpuregs\[30\]\[22\] VGND VGND VPWR VPWR net1759 sky130_fd_sc_hd__dlygate4sd3_1
Xhold640 cpuregs\[15\]\[10\] VGND VGND VPWR VPWR net1748 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold695 cpuregs\[2\]\[27\] VGND VGND VPWR VPWR net1803 sky130_fd_sc_hd__dlygate4sd3_1
Xhold673 cpuregs\[25\]\[10\] VGND VGND VPWR VPWR net1781 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold684 cpuregs\[8\]\[9\] VGND VGND VPWR VPWR net1792 sky130_fd_sc_hd__dlygate4sd3_1
X_09968_ clknet_leaf_58_clk _00092_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dfxtp_1
XFILLER_77_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08919_ cpuregs\[24\]\[24\] cpuregs\[25\]\[24\] cpuregs\[26\]\[24\] cpuregs\[27\]\[24\]
+ net971 net936 VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__mux4_1
X_09899_ net1131 VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__clkbuf_1
XFILLER_150_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10812_ clknet_leaf_92_clk _00871_ VGND VGND VPWR VPWR instr_sub sky130_fd_sc_hd__dfxtp_1
XFILLER_26_783 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10743_ clknet_leaf_63_clk _00834_ VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dfxtp_4
XTAP_TAPCELL_ROW_136_2504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_2515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10674_ clknet_leaf_64_clk _04899_ VGND VGND VPWR VPWR reg_out\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11226_ clknet_leaf_8_clk _01267_ VGND VGND VPWR VPWR cpuregs\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11157_ clknet_leaf_13_clk _01198_ VGND VGND VPWR VPWR cpuregs\[23\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_10108_ clknet_leaf_119_clk _00232_ VGND VGND VPWR VPWR cpuregs\[28\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_147_2688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11088_ clknet_leaf_12_clk _01139_ VGND VGND VPWR VPWR cpuregs\[24\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_10039_ clknet_leaf_24_clk _00163_ VGND VGND VPWR VPWR cpuregs\[30\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_683 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05580_ _02148_ _02152_ _02155_ _02159_ VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__or4_1
XFILLER_63_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_149_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07250_ net1430 net277 net460 VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__mux2_1
X_07181_ net1963 net273 net468 VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__mux2_1
XFILLER_118_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06201_ net291 net1909 net478 VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__mux2_1
XFILLER_145_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06132_ _02593_ _02594_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__nor2_1
XFILLER_118_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06063_ cpuregs\[24\]\[2\] cpuregs\[25\]\[2\] cpuregs\[26\]\[2\] cpuregs\[27\]\[2\]
+ net957 net922 VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__mux4_1
Xfanout405 _04802_ VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__buf_4
X_05014_ _01630_ _01632_ _01633_ _01595_ VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__o31a_1
X_09822_ net270 net1730 net351 VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__mux2_1
Xfanout416 net417 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__clkbuf_8
XFILLER_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout427 _03578_ VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__buf_4
Xfanout438 net439 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__clkbuf_8
XFILLER_113_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09753_ net279 net2079 net359 VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__mux2_1
Xfanout449 _03572_ VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__buf_4
X_06965_ _03327_ _03351_ _03352_ VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__nand3_1
XFILLER_58_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08704_ cpuregs\[12\]\[12\] cpuregs\[13\]\[12\] cpuregs\[14\]\[12\] cpuregs\[15\]\[12\]
+ net946 net911 VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__mux4_1
X_06896_ cpuregs\[8\]\[21\] cpuregs\[9\]\[21\] cpuregs\[10\]\[21\] cpuregs\[11\]\[21\]
+ net798 net761 VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__mux4_1
XFILLER_104_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05916_ _02097_ net580 net542 _02464_ VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_100_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_87_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09684_ net1644 net291 net367 VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__mux2_1
XFILLER_55_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05847_ _02058_ _02403_ net542 VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__a21o_1
XFILLER_82_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08635_ _04320_ _04321_ net669 VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__mux2_1
X_08566_ cpuregs\[20\]\[5\] cpuregs\[21\]\[5\] cpuregs\[22\]\[5\] cpuregs\[23\]\[5\]
+ net944 net909 VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__mux4_1
X_07517_ net1668 net271 net428 VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__mux2_1
X_05778_ _02156_ _02333_ _02201_ VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_25_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08497_ net81 net1195 net408 VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__mux2_1
XFILLER_80_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_118_2223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07448_ net1874 net284 net436 VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__mux2_1
XFILLER_23_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07379_ net292 net1734 net444 VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__mux2_1
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09118_ net555 _04749_ VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__and2_1
XFILLER_6_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_135_143 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_131_2434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_2423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10390_ clknet_leaf_73_clk _00514_ VGND VGND VPWR VPWR cpuregs\[25\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_98_1897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09049_ cpuregs\[4\]\[31\] cpuregs\[5\]\[31\] cpuregs\[6\]\[31\] cpuregs\[7\]\[31\]
+ net962 net927 VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__mux4_1
Xhold470 cpuregs\[15\]\[18\] VGND VGND VPWR VPWR net1578 sky130_fd_sc_hd__dlygate4sd3_1
Xhold481 cpuregs\[2\]\[3\] VGND VGND VPWR VPWR net1589 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold492 cpuregs\[30\]\[30\] VGND VGND VPWR VPWR net1600 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_89_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11011_ clknet_leaf_149_clk _01067_ VGND VGND VPWR VPWR cpuregs\[19\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xfanout961 net968 VGND VGND VPWR VPWR net961 sky130_fd_sc_hd__buf_4
Xfanout950 net952 VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__buf_4
Xfanout972 net975 VGND VGND VPWR VPWR net972 sky130_fd_sc_hd__buf_4
Xfanout994 net999 VGND VGND VPWR VPWR net994 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout983 net990 VGND VGND VPWR VPWR net983 sky130_fd_sc_hd__buf_1
XFILLER_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1170 count_cycle\[22\] VGND VGND VPWR VPWR net2278 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_64_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1181 count_instr\[23\] VGND VGND VPWR VPWR net2289 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1192 mem_rdata_q\[3\] VGND VGND VPWR VPWR net2300 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_142_2596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10726_ clknet_leaf_17_clk _00817_ VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dfxtp_2
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10657_ clknet_leaf_135_clk _04912_ VGND VGND VPWR VPWR reg_out\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload26 clknet_leaf_12_clk VGND VGND VPWR VPWR clkload26/X sky130_fd_sc_hd__clkbuf_4
Xclkload15 clknet_leaf_1_clk VGND VGND VPWR VPWR clkload15/X sky130_fd_sc_hd__clkbuf_8
Xclkload59 clknet_leaf_33_clk VGND VGND VPWR VPWR clkload59/Y sky130_fd_sc_hd__inv_8
Xclkload37 clknet_leaf_147_clk VGND VGND VPWR VPWR clkload37/Y sky130_fd_sc_hd__clkinv_8
Xclkload48 clknet_leaf_138_clk VGND VGND VPWR VPWR clkload48/Y sky130_fd_sc_hd__clkinv_2
X_10588_ clknet_leaf_108_clk _00712_ VGND VGND VPWR VPWR count_cycle\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_115_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_149_2717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_130_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11209_ clknet_leaf_75_clk _01250_ VGND VGND VPWR VPWR cpuregs\[29\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06750_ decoded_imm\[16\] net870 VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__or2_1
XFILLER_37_823 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06681_ cpuregs\[28\]\[13\] cpuregs\[29\]\[13\] cpuregs\[30\]\[13\] cpuregs\[31\]\[13\]
+ net781 net745 VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__mux4_1
X_05701_ _02162_ _02168_ _02269_ _02161_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__a31o_1
X_05632_ _02067_ _02211_ _02210_ VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__a21o_1
X_08420_ count_cycle\[58\] _04157_ count_cycle\[59\] VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__a21o_1
XFILLER_52_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_149_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05563_ net886 net108 VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__or2_1
X_08351_ net2284 _04114_ net979 VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__o21ai_1
X_05494_ net867 net212 VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__nor2_1
X_08282_ net2277 _04070_ _04072_ VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__a21oi_1
X_07302_ net1311 net341 net450 VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__mux2_1
XFILLER_149_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07233_ net1269 net492 net459 VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__mux2_1
Xclkload9 clknet_4_10_0_clk VGND VGND VPWR VPWR clkload9/Y sky130_fd_sc_hd__inv_6
XFILLER_117_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07164_ net1587 net475 net466 VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__mux2_1
X_07095_ cpuregs\[28\]\[28\] cpuregs\[29\]\[28\] cpuregs\[30\]\[28\] cpuregs\[31\]\[28\]
+ net807 net770 VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_113_2142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06115_ latched_branch latched_store VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__nand2b_2
XFILLER_132_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06046_ _00841_ _02516_ VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__nand2b_1
XFILLER_114_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout246 _02700_ VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__clkbuf_2
XFILLER_113_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout257 _02687_ VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__clkbuf_2
Xfanout268 _02674_ VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__buf_1
XFILLER_140_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout279 net282 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__clkbuf_2
X_07997_ _03815_ _03816_ VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__and2_1
X_09805_ net472 net2082 net349 VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__mux2_1
XFILLER_101_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06948_ net497 _03278_ _03359_ _03358_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__a31o_1
X_09736_ net527 net1762 net358 VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__mux2_1
XFILLER_67_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09667_ net1370 net538 net366 VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__mux2_1
XFILLER_28_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06879_ _03289_ _03290_ net653 VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__mux2_1
X_08618_ _04300_ _04301_ net670 VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__mux2_1
X_09598_ net1652 net236 net379 VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__mux2_1
XFILLER_70_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08549_ cpuregs\[28\]\[1\] cpuregs\[29\]\[1\] cpuregs\[30\]\[1\] cpuregs\[31\]\[1\]
+ net955 net920 VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__mux4_1
XFILLER_23_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10511_ clknet_leaf_83_clk _00635_ VGND VGND VPWR VPWR count_instr\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_50_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11491_ clknet_leaf_25_clk _01529_ VGND VGND VPWR VPWR cpuregs\[10\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10442_ clknet_leaf_31_clk _00566_ VGND VGND VPWR VPWR cpuregs\[17\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10373_ clknet_leaf_12_clk _00497_ VGND VGND VPWR VPWR cpuregs\[25\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_861 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_382 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_144_2636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout791 net793 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__buf_4
Xfanout780 net781 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__buf_4
XFILLER_65_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10709_ clknet_leaf_82_clk _00801_ VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dfxtp_1
Xclkload104 clknet_leaf_116_clk VGND VGND VPWR VPWR clkload104/Y sky130_fd_sc_hd__clkinv_8
Xclkload126 clknet_leaf_68_clk VGND VGND VPWR VPWR clkload126/Y sky130_fd_sc_hd__clkinv_2
Xclkload137 clknet_leaf_86_clk VGND VGND VPWR VPWR clkload137/Y sky130_fd_sc_hd__clkinvlp_4
Xclkload115 clknet_leaf_107_clk VGND VGND VPWR VPWR clkload115/Y sky130_fd_sc_hd__bufinv_16
XFILLER_115_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07920_ _03743_ _03746_ net2217 net503 VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_69_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07851_ _02610_ reg_next_pc\[8\] net569 VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__mux2_2
XFILLER_111_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06802_ decoded_imm\[18\] net867 VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__and2_1
X_07782_ count_instr\[44\] count_instr\[43\] count_instr\[42\] _03657_ VGND VGND VPWR
+ VPWR _03662_ sky130_fd_sc_hd__and4_1
Xinput2 mem_rdata[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__dlymetal6s2s_1
X_09521_ net1409 net281 net387 VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__mux2_1
X_06733_ cpuregs\[28\]\[15\] cpuregs\[29\]\[15\] cpuregs\[30\]\[15\] cpuregs\[31\]\[15\]
+ net783 net747 VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__mux4_1
X_04994_ net851 net984 _01608_ VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__and3b_2
XFILLER_37_653 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09452_ net291 net1841 net394 VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__mux2_1
X_06664_ _03083_ _03084_ _03085_ _03086_ net727 net722 VGND VGND VPWR VPWR _03087_
+ sky130_fd_sc_hd__mux4_2
XFILLER_36_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08403_ net2295 _04146_ _04148_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__a21oi_1
X_05615_ _02124_ _02194_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__nand2_1
X_06595_ net606 _03015_ _03016_ _03019_ net523 VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__a311o_1
X_09383_ net833 decoded_imm_j\[7\] _04826_ mem_rdata_q\[27\] net551 VGND VGND VPWR
+ VPWR _04854_ sky130_fd_sc_hd__a221o_1
XFILLER_52_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08334_ count_cycle\[25\] count_cycle\[26\] count_cycle\[27\] _04100_ VGND VGND VPWR
+ VPWR _04105_ sky130_fd_sc_hd__and4_1
X_05546_ net883 net846 VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_35_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05477_ net861 net217 VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__or2_1
X_08265_ count_cycle\[0\] count_cycle\[1\] net983 VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__o21ai_1
X_07216_ net1620 net278 net463 VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__mux2_1
X_08196_ net813 _03723_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__nor2_1
X_07147_ _03543_ _03544_ _03548_ _03549_ net655 net642 VGND VGND VPWR VPWR _03552_
+ sky130_fd_sc_hd__mux4_1
XFILLER_118_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07078_ _03383_ _03481_ _03483_ _03484_ VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__o211a_1
XFILLER_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06029_ mem_rdata_q\[22\] net15 net611 VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__mux2_1
XFILLER_120_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_575 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_126_2355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_2344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09719_ net283 net1860 net363 VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__mux2_1
X_10991_ clknet_leaf_28_clk _01047_ VGND VGND VPWR VPWR cpuregs\[18\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_46_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11612_ net108 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_1
XFILLER_24_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11474_ clknet_leaf_118_clk _01512_ VGND VGND VPWR VPWR cpuregs\[10\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_10425_ clknet_leaf_119_clk _00549_ VGND VGND VPWR VPWR cpuregs\[17\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_731 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10356_ clknet_leaf_72_clk _00480_ VGND VGND VPWR VPWR cpuregs\[16\]\[28\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_115_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10287_ clknet_leaf_47_clk _00411_ VGND VGND VPWR VPWR cpuregs\[15\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_612 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_124_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05400_ reg_pc\[27\] decoded_imm\[27\] VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_32_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06380_ reg_pc\[2\] net526 net563 _02811_ _02812_ VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__a32o_1
X_05331_ count_cycle\[21\] net619 net591 _01921_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__o211a_1
XFILLER_119_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05262_ _01829_ _01838_ _01839_ VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__o21a_1
X_08050_ net685 _03865_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__nand2_1
X_07001_ net853 net514 VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_133_Left_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_77_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05193_ _01780_ _01783_ _01792_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__a21o_1
XFILLER_142_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_143_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08952_ decoded_imm\[25\] net599 net628 VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__a21o_1
X_08883_ cpuregs\[28\]\[22\] cpuregs\[29\]\[22\] cpuregs\[30\]\[22\] cpuregs\[31\]\[22\]
+ net963 net928 VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__mux4_1
XFILLER_130_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07903_ net603 _03730_ _03731_ net503 net1150 VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__a32o_1
X_07834_ net1187 _03692_ _03694_ VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__a21oi_1
XFILLER_111_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_142_Left_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_2063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04977_ _01601_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__inv_2
X_07765_ _03651_ net981 _03650_ VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__and3b_1
X_06716_ net524 _03119_ _03121_ _03122_ _03136_ VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__o41a_1
X_07696_ _03607_ net987 _03606_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__and3b_1
X_09504_ net1231 net527 net386 VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_121_2263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06647_ net606 _03069_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__nand2_1
X_09435_ net539 net1886 net393 VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_121_2274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09366_ net838 decoded_imm_j\[15\] _01577_ mem_rdata_q\[15\] VGND VGND VPWR VPWR
+ _04845_ sky130_fd_sc_hd__a22o_1
X_06578_ _02997_ _02998_ net644 VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__mux2_1
XANTENNA_40 _04895_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09297_ net1160 net111 net484 VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__mux2_1
X_05529_ _02082_ _02087_ _02100_ _02108_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__or4b_1
X_08317_ _04094_ net993 _04093_ VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__and3b_1
X_08248_ _04044_ _04045_ _04047_ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__o21ai_1
XANTENNA_51 net126 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_62 net227 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_84 net684 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_73 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_95 net860 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_106_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08179_ net690 reg_next_pc\[24\] net547 _03721_ VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__a22o_1
X_10210_ clknet_leaf_16_clk _00334_ VGND VGND VPWR VPWR cpuregs\[14\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11190_ clknet_leaf_150_clk _01231_ VGND VGND VPWR VPWR cpuregs\[29\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10141_ clknet_leaf_139_clk _00265_ VGND VGND VPWR VPWR cpuregs\[21\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xoutput191 net191 VGND VGND VPWR VPWR pcpi_rs1[28] sky130_fd_sc_hd__buf_2
Xoutput180 net180 VGND VGND VPWR VPWR pcpi_rs1[18] sky130_fd_sc_hd__buf_2
XFILLER_0_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10072_ clknet_leaf_138_clk _00196_ VGND VGND VPWR VPWR cpuregs\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10974_ clknet_leaf_138_clk _01030_ VGND VGND VPWR VPWR cpuregs\[18\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_139_2557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_152_2757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_2768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11457_ clknet_leaf_31_clk _01495_ VGND VGND VPWR VPWR cpuregs\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10408_ clknet_leaf_54_clk _00532_ VGND VGND VPWR VPWR cpuregs\[20\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_59_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11388_ clknet_leaf_6_clk _01426_ VGND VGND VPWR VPWR cpuregs\[7\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10339_ clknet_leaf_1_clk _00463_ VGND VGND VPWR VPWR cpuregs\[16\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05880_ _02092_ _02419_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__or2_1
XFILLER_78_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07550_ net276 net2163 net423 VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06501_ _02919_ _02920_ net731 VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__mux2_1
X_07481_ net2073 net283 net432 VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__mux2_1
X_09220_ net1214 net548 _04800_ is_alu_reg_imm VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__a22o_1
XFILLER_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06432_ net723 _02845_ _02849_ _02862_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__a31o_1
X_09151_ net976 is_alu_reg_reg _04775_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__and3_1
X_06363_ cpuregs\[28\]\[2\] cpuregs\[29\]\[2\] cpuregs\[30\]\[2\] cpuregs\[31\]\[2\]
+ net788 net752 VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__mux4_1
XFILLER_148_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05314_ _01903_ _01904_ net714 VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__a21bo_1
X_08102_ _03715_ _03892_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__nor2_1
X_09082_ net2348 net29 net613 VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__mux2_1
XFILLER_135_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08033_ decoded_imm_j\[12\] _03708_ _03823_ VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__a21o_1
X_06294_ net641 _02728_ net638 VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__a21o_1
Xhold800 cpuregs\[19\]\[18\] VGND VGND VPWR VPWR net1908 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05245_ _01840_ _01841_ net714 VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__o21ai_1
Xhold811 cpuregs\[28\]\[1\] VGND VGND VPWR VPWR net1919 sky130_fd_sc_hd__dlygate4sd3_1
Xhold855 cpuregs\[12\]\[22\] VGND VGND VPWR VPWR net1963 sky130_fd_sc_hd__dlygate4sd3_1
Xhold833 cpuregs\[1\]\[28\] VGND VGND VPWR VPWR net1941 sky130_fd_sc_hd__dlygate4sd3_1
Xhold844 cpuregs\[18\]\[27\] VGND VGND VPWR VPWR net1952 sky130_fd_sc_hd__dlygate4sd3_1
Xhold822 cpuregs\[10\]\[16\] VGND VGND VPWR VPWR net1930 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_742 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05176_ net711 _01771_ _01772_ _01778_ VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__a31o_1
Xmax_cap541 _02527_ VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__buf_2
XFILLER_143_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold877 cpuregs\[11\]\[13\] VGND VGND VPWR VPWR net1985 sky130_fd_sc_hd__dlygate4sd3_1
Xhold888 cpuregs\[16\]\[8\] VGND VGND VPWR VPWR net1996 sky130_fd_sc_hd__dlygate4sd3_1
Xhold866 cpuregs\[28\]\[0\] VGND VGND VPWR VPWR net1974 sky130_fd_sc_hd__dlygate4sd3_1
Xhold899 cpuregs\[11\]\[20\] VGND VGND VPWR VPWR net2007 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09984_ clknet_leaf_138_clk _00108_ VGND VGND VPWR VPWR cpuregs\[12\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_08935_ cpuregs\[24\]\[25\] cpuregs\[25\]\[25\] cpuregs\[26\]\[25\] cpuregs\[27\]\[25\]
+ net971 net936 VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__mux4_1
XFILLER_97_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_150_Left_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08866_ cpuregs\[24\]\[21\] cpuregs\[25\]\[21\] cpuregs\[26\]\[21\] cpuregs\[27\]\[21\]
+ net964 net929 VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_123_2303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07817_ count_instr\[57\] _03682_ net1000 VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__o21ai_1
X_08797_ cpuregs\[0\]\[17\] cpuregs\[1\]\[17\] cpuregs\[2\]\[17\] cpuregs\[3\]\[17\]
+ net958 net923 VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__mux4_1
X_07748_ count_instr\[31\] count_instr\[30\] _03637_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__and3_1
XFILLER_83_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07679_ count_instr\[6\] count_instr\[5\] _03593_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__and3_1
XFILLER_13_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09418_ net296 net2064 net399 VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__mux2_1
X_10690_ clknet_leaf_144_clk _00782_ VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_101_1955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09349_ decoded_imm\[24\] net553 net401 _04836_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_23_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11311_ clknet_leaf_122_clk _01352_ VGND VGND VPWR VPWR cpuregs\[5\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_134_2476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11242_ clknet_leaf_76_clk _01283_ VGND VGND VPWR VPWR cpuregs\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11173_ clknet_leaf_57_clk _01214_ VGND VGND VPWR VPWR cpuregs\[23\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_10124_ clknet_leaf_35_clk _00248_ VGND VGND VPWR VPWR cpuregs\[28\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10055_ clknet_leaf_21_clk _00179_ VGND VGND VPWR VPWR cpuregs\[13\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10957_ clknet_leaf_92_clk _01013_ VGND VGND VPWR VPWR decoded_imm\[17\] sky130_fd_sc_hd__dfxtp_2
X_10888_ clknet_leaf_49_clk _00944_ VGND VGND VPWR VPWR cpuregs\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_12_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold107 _00913_ VGND VGND VPWR VPWR net1215 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_74_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05030_ _01623_ _01625_ _01554_ VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__a21oi_2
Xhold129 cpuregs\[21\]\[2\] VGND VGND VPWR VPWR net1237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold118 cpuregs\[21\]\[3\] VGND VGND VPWR VPWR net1226 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_113_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout609 _01612_ VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__buf_4
XFILLER_140_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06981_ cpuregs\[4\]\[24\] cpuregs\[5\]\[24\] cpuregs\[6\]\[24\] cpuregs\[7\]\[24\]
+ net801 net762 VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__mux4_1
XFILLER_39_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08720_ cpuregs\[4\]\[13\] cpuregs\[5\]\[13\] cpuregs\[6\]\[13\] cpuregs\[7\]\[13\]
+ net948 net913 VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__mux4_1
X_05932_ net697 net108 net234 net694 VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__a22o_1
X_05863_ _02054_ _02058_ _02370_ _02414_ _02418_ VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__o41a_1
XFILLER_78_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08651_ net669 _04340_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_105_2011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07602_ net1916 net470 net414 VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05794_ _02206_ _02357_ net693 VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__mux2_1
X_08582_ net890 _04274_ net664 VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_85_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07533_ net493 net1921 net425 VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__mux2_1
XFILLER_34_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_85_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07464_ net1270 net532 net431 VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__mux2_1
XFILLER_50_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06415_ cpuregs\[28\]\[4\] cpuregs\[29\]\[4\] cpuregs\[30\]\[4\] cpuregs\[31\]\[4\]
+ net786 net750 VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__mux4_1
X_09203_ net1228 net31 net612 VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__mux2_1
X_09134_ net1415 net499 _04762_ _04767_ VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__a22o_1
X_07395_ net2062 net538 net438 VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__mux2_1
XFILLER_108_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06346_ net886 decoded_imm\[1\] VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__or2_1
XFILLER_136_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06277_ cpuregs\[12\]\[0\] cpuregs\[13\]\[0\] cpuregs\[14\]\[0\] cpuregs\[15\]\[0\]
+ net782 net746 VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__mux4_1
X_09065_ net718 cpu_state\[2\] _01662_ _04731_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_116_2195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_2184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05228_ net709 net873 _01823_ net702 _01826_ VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__a221o_1
X_08016_ net688 reg_next_pc\[11\] net545 _03707_ VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__a22o_1
Xhold630 cpuregs\[1\]\[5\] VGND VGND VPWR VPWR net1738 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold652 cpuregs\[26\]\[7\] VGND VGND VPWR VPWR net1760 sky130_fd_sc_hd__dlygate4sd3_1
Xhold641 cpuregs\[12\]\[6\] VGND VGND VPWR VPWR net1749 sky130_fd_sc_hd__dlygate4sd3_1
Xhold663 cpuregs\[16\]\[9\] VGND VGND VPWR VPWR net1771 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold685 cpuregs\[10\]\[20\] VGND VGND VPWR VPWR net1793 sky130_fd_sc_hd__dlygate4sd3_1
Xhold674 cpuregs\[20\]\[19\] VGND VGND VPWR VPWR net1782 sky130_fd_sc_hd__dlygate4sd3_1
Xhold696 cpuregs\[29\]\[14\] VGND VGND VPWR VPWR net1804 sky130_fd_sc_hd__dlygate4sd3_1
X_05159_ _01760_ _01762_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__or2_1
XFILLER_1_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09967_ clknet_leaf_57_clk _00091_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dfxtp_1
XFILLER_103_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08918_ cpuregs\[28\]\[24\] cpuregs\[29\]\[24\] cpuregs\[30\]\[24\] cpuregs\[31\]\[24\]
+ net971 net936 VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__mux4_1
XFILLER_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09898_ net1119 VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__clkbuf_1
X_08849_ cpuregs\[0\]\[20\] cpuregs\[1\]\[20\] cpuregs\[2\]\[20\] cpuregs\[3\]\[20\]
+ net963 net928 VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__mux4_1
XFILLER_85_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_150_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10811_ clknet_leaf_98_clk _00870_ VGND VGND VPWR VPWR instr_add sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_28_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10742_ clknet_leaf_64_clk _00833_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dfxtp_2
XFILLER_53_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_795 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_136_2505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10673_ clknet_leaf_64_clk _04898_ VGND VGND VPWR VPWR reg_out\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11225_ clknet_leaf_6_clk _01266_ VGND VGND VPWR VPWR cpuregs\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_564 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11156_ clknet_leaf_152_clk _01197_ VGND VGND VPWR VPWR cpuregs\[23\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_8_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11087_ clknet_leaf_13_clk _01138_ VGND VGND VPWR VPWR cpuregs\[24\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_10107_ clknet_leaf_124_clk _00231_ VGND VGND VPWR VPWR cpuregs\[28\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_147_2689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10038_ clknet_leaf_73_clk _00162_ VGND VGND VPWR VPWR cpuregs\[30\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06200_ _02646_ _02649_ net567 VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__mux2_2
XPHY_EDGE_ROW_140_Right_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07180_ net2054 net277 net468 VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__mux2_1
XFILLER_118_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06131_ reg_pc\[3\] reg_pc\[2\] reg_pc\[4\] VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__a21oi_1
X_06062_ cpuregs\[28\]\[2\] cpuregs\[29\]\[2\] cpuregs\[30\]\[2\] cpuregs\[31\]\[2\]
+ net956 net921 VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__mux4_1
XFILLER_145_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_126_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05013_ net712 net810 _01602_ _00841_ VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__a31o_1
XFILLER_99_754 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09821_ net274 net2234 net351 VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__mux2_1
XFILLER_98_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout428 net429 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__clkbuf_8
Xfanout417 _03583_ VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__clkbuf_8
Xfanout406 net407 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__clkbuf_4
Xfanout439 _03574_ VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__buf_4
XFILLER_141_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09752_ net283 net2159 net359 VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__mux2_1
X_06964_ net859 net303 _03375_ VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__a21o_1
X_08703_ net900 _04389_ VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__or2_1
X_06895_ cpuregs\[12\]\[21\] cpuregs\[13\]\[21\] cpuregs\[14\]\[21\] cpuregs\[15\]\[21\]
+ net797 net760 VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__mux4_1
X_09683_ net1783 net297 net368 VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__mux2_1
X_05915_ _02097_ _02245_ net586 VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_87_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05846_ _02058_ _02403_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__nor2_1
XFILLER_66_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08634_ net669 _04315_ net889 VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__o21a_1
X_05777_ _02341_ _02342_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__or2_1
X_08565_ _04258_ _04259_ net123 net626 VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_42_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07516_ net1496 net277 net428 VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08496_ net80 net1207 net408 VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__mux2_1
XFILLER_50_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_118_2213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07447_ net1816 net290 net436 VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_118_2224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07378_ net297 net2131 net444 VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__mux2_1
XFILLER_148_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09117_ net2375 _02515_ _04744_ _04759_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__a22o_1
X_06329_ cpuregs\[27\]\[1\] net788 net752 VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_131_2424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09048_ net902 _04715_ VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_98_1898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_131_2435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold460 cpuregs\[1\]\[24\] VGND VGND VPWR VPWR net1568 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold471 cpuregs\[17\]\[15\] VGND VGND VPWR VPWR net1579 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold482 cpuregs\[29\]\[10\] VGND VGND VPWR VPWR net1590 sky130_fd_sc_hd__dlygate4sd3_1
X_11010_ clknet_leaf_144_clk _01066_ VGND VGND VPWR VPWR cpuregs\[19\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xhold493 cpuregs\[17\]\[3\] VGND VGND VPWR VPWR net1601 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout940 _00008_ VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__clkbuf_4
Xfanout951 net952 VGND VGND VPWR VPWR net951 sky130_fd_sc_hd__buf_2
Xfanout973 net975 VGND VGND VPWR VPWR net973 sky130_fd_sc_hd__buf_2
Xfanout962 net968 VGND VGND VPWR VPWR net962 sky130_fd_sc_hd__buf_2
Xfanout995 net999 VGND VGND VPWR VPWR net995 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout984 net989 VGND VGND VPWR VPWR net984 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_51_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_129_2397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1160 count_cycle\[55\] VGND VGND VPWR VPWR net2268 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1171 count_instr\[29\] VGND VGND VPWR VPWR net2279 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_85_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1193 count_instr\[41\] VGND VGND VPWR VPWR net2301 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1182 count_cycle\[40\] VGND VGND VPWR VPWR net2290 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_73_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_142_2597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10725_ clknet_leaf_15_clk _00816_ VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dfxtp_2
XFILLER_41_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10656_ clknet_leaf_133_clk _04911_ VGND VGND VPWR VPWR reg_out\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_595 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload16 clknet_leaf_2_clk VGND VGND VPWR VPWR clkload16/Y sky130_fd_sc_hd__bufinv_16
Xclkload49 clknet_leaf_22_clk VGND VGND VPWR VPWR clkload49/Y sky130_fd_sc_hd__inv_6
Xclkload27 clknet_leaf_13_clk VGND VGND VPWR VPWR clkload27/X sky130_fd_sc_hd__clkbuf_8
Xclkload38 clknet_leaf_148_clk VGND VGND VPWR VPWR clkload38/Y sky130_fd_sc_hd__clkinv_4
XFILLER_5_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10587_ clknet_leaf_109_clk _00711_ VGND VGND VPWR VPWR count_cycle\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_149_2718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11208_ clknet_leaf_64_clk _01249_ VGND VGND VPWR VPWR cpuregs\[29\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11139_ clknet_leaf_43_clk _01180_ VGND VGND VPWR VPWR cpuregs\[31\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_69_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06680_ cpuregs\[8\]\[13\] cpuregs\[9\]\[13\] cpuregs\[10\]\[13\] cpuregs\[11\]\[13\]
+ net781 net745 VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__mux4_1
X_05700_ _02272_ _02273_ _02275_ VGND VGND VPWR VPWR alu_out\[4\] sky130_fd_sc_hd__a21o_1
X_05631_ net215 net864 VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__and2b_1
XFILLER_91_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08350_ count_cycle\[32\] count_cycle\[33\] count_cycle\[31\] _04110_ VGND VGND VPWR
+ VPWR _04115_ sky130_fd_sc_hd__and4_1
XFILLER_24_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05562_ _02140_ _02141_ VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__nand2_1
X_07301_ net1491 net471 net450 VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__mux2_1
XFILLER_32_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05493_ net867 net212 VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__nand2_2
X_08281_ count_cycle\[7\] _04070_ net985 VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__o21ai_1
Xclkbuf_leaf_152_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_152_clk sky130_fd_sc_hd__clkbuf_8
X_07232_ net1219 _02591_ net459 VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__mux2_1
X_07163_ net2019 net492 net467 VGND VGND VPWR VPWR _00104_ sky130_fd_sc_hd__mux2_1
XFILLER_118_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06114_ _02578_ _02580_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__or2_4
X_07094_ cpuregs\[8\]\[28\] cpuregs\[9\]\[28\] cpuregs\[10\]\[28\] cpuregs\[11\]\[28\]
+ net805 net768 VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_113_2143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06045_ net712 net810 net609 _02241_ _02515_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__a41o_1
Xfanout247 net249 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__clkbuf_2
Xfanout236 net237 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_2
X_09804_ _02601_ net1704 net349 VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__mux2_1
Xfanout258 _02687_ VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_1
Xfanout269 _02674_ VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__clkbuf_2
XFILLER_87_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07996_ decoded_imm_j\[10\] _03706_ VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__or2_1
X_06947_ net861 net511 VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__or2_1
XFILLER_86_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09735_ net530 net2105 net358 VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__mux2_1
XFILLER_28_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09666_ _03561_ _04873_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__nor2_2
XFILLER_131_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06878_ _03285_ _03286_ net653 VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__mux2_1
X_08617_ _04298_ _04307_ _04308_ net658 net895 VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__a221o_1
XFILLER_15_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_19_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09597_ net1344 net239 net379 VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__mux2_1
X_05829_ _02062_ _02388_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__xnor2_1
X_08548_ _04244_ _04245_ net674 VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__mux2_1
XFILLER_11_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08479_ net93 net1197 net406 VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_143_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_143_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_128_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11490_ clknet_leaf_34_clk _01528_ VGND VGND VPWR VPWR cpuregs\[10\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_10510_ clknet_leaf_83_clk _00634_ VGND VGND VPWR VPWR count_instr\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10441_ clknet_leaf_31_clk _00565_ VGND VGND VPWR VPWR cpuregs\[17\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10372_ clknet_leaf_13_clk _00496_ VGND VGND VPWR VPWR cpuregs\[25\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_873 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_724 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold290 cpuregs\[23\]\[7\] VGND VGND VPWR VPWR net1398 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_144_2637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout770 net771 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__clkbuf_4
Xfanout792 net793 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__buf_4
XFILLER_93_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout781 net784 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__buf_2
XFILLER_65_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_37_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_462 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_134_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_134_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_64_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10708_ clknet_leaf_82_clk _00800_ VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dfxtp_1
XFILLER_146_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload127 clknet_leaf_69_clk VGND VGND VPWR VPWR clkload127/Y sky130_fd_sc_hd__inv_8
X_10639_ clknet_leaf_82_clk _00763_ VGND VGND VPWR VPWR count_cycle\[56\] sky130_fd_sc_hd__dfxtp_1
Xclkload116 clknet_leaf_109_clk VGND VGND VPWR VPWR clkload116/Y sky130_fd_sc_hd__inv_6
Xclkload105 clknet_leaf_117_clk VGND VGND VPWR VPWR clkload105/Y sky130_fd_sc_hd__inv_12
Xclkload138 clknet_leaf_88_clk VGND VGND VPWR VPWR clkload138/Y sky130_fd_sc_hd__bufinv_16
XFILLER_142_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_142_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_111_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07850_ reg_pc\[7\] net502 _03703_ net602 VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__a22o_1
XFILLER_110_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06801_ decoded_imm\[18\] net867 VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__nor2_1
XFILLER_68_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07781_ _03661_ net986 _03660_ VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__and3b_1
X_04993_ cpu_state\[1\] net978 VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__and2_2
X_09520_ net1455 net284 net387 VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__mux2_1
X_06732_ cpuregs\[8\]\[15\] cpuregs\[9\]\[15\] cpuregs\[10\]\[15\] cpuregs\[11\]\[15\]
+ net795 net758 VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__mux4_1
Xinput3 mem_rdata[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_37_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09451_ net296 net1811 net395 VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__mux2_1
XFILLER_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06663_ _03077_ _03078_ net646 VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__mux2_1
X_08402_ count_cycle\[52\] _04146_ net998 VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__o21ai_1
X_06594_ net488 _02939_ _03017_ _03018_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__a31o_1
X_05614_ _02135_ _02139_ _02193_ _02179_ VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__a31o_1
X_09382_ decoded_imm\[8\] net552 _04853_ VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__o21a_1
XFILLER_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08333_ _04104_ net992 _04103_ VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__and3b_1
X_05545_ _02121_ _02124_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_125_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_125_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_35_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08264_ count_cycle\[0\] net983 VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__and2b_1
X_05476_ net861 net217 VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__nor2_1
X_08195_ net813 _03723_ VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__and2_1
X_07215_ net1449 net281 net463 VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__mux2_1
XFILLER_20_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_773 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07146_ cpuregs\[16\]\[30\] cpuregs\[17\]\[30\] cpuregs\[18\]\[30\] cpuregs\[19\]\[30\]
+ net807 net770 VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_95_1846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_659 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07077_ _03431_ _03452_ _03482_ _03453_ VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_95_1857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06028_ decoded_imm_j\[1\] _01115_ net330 VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__mux2_1
XFILLER_59_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_126_2345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09718_ net287 net2181 net363 VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__mux2_1
X_07979_ net977 _03800_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__and2_1
X_10990_ clknet_leaf_44_clk _01046_ VGND VGND VPWR VPWR cpuregs\[18\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_55_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09649_ net296 net2228 net370 VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_150_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11611_ net97 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_46_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_116_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_116_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_24_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11473_ clknet_leaf_119_clk _01511_ VGND VGND VPWR VPWR cpuregs\[10\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10424_ clknet_leaf_139_clk _00548_ VGND VGND VPWR VPWR cpuregs\[17\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_743 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10355_ clknet_leaf_69_clk _00479_ VGND VGND VPWR VPWR cpuregs\[16\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10286_ clknet_leaf_40_clk _00410_ VGND VGND VPWR VPWR cpuregs\[15\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05330_ net825 count_cycle\[53\] net623 _01920_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__a211o_1
Xclkbuf_leaf_107_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_107_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_32_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05261_ _01817_ _01856_ _01853_ VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__a21o_1
X_07000_ net858 net511 _03332_ net498 VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05192_ _01780_ _01783_ _01792_ VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_77_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08951_ _04623_ _04624_ net481 _04621_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__o211a_1
X_08882_ cpuregs\[8\]\[22\] cpuregs\[9\]\[22\] cpuregs\[10\]\[22\] cpuregs\[11\]\[22\]
+ net964 net929 VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__mux4_1
XFILLER_130_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07902_ net835 net848 decoded_imm_j\[1\] _03695_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__a31o_1
XFILLER_110_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07833_ net1187 _03692_ net1001 VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__o21ai_1
XFILLER_97_874 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_2064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04976_ mem_do_rinst _01597_ _01600_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__a21oi_4
X_07764_ count_instr\[37\] count_instr\[36\] _03647_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__and3_1
X_06715_ reg_pc\[14\] net561 _03135_ net517 net521 VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__a221o_1
X_07695_ count_instr\[12\] count_instr\[11\] _03603_ VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__and3_1
XFILLER_65_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09503_ net1854 net532 net386 VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__mux2_1
XFILLER_80_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06646_ _03040_ _03066_ _03068_ _03065_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__a31o_1
X_09434_ _02580_ _03579_ VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_121_2275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_2264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09365_ net2354 net553 _04827_ _04844_ VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__o22a_1
XFILLER_21_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06577_ _03001_ _03002_ net644 VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__mux2_1
XFILLER_138_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05528_ _02092_ _02095_ _02104_ _02107_ VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__and4_1
X_09296_ net1161 net110 net484 VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__mux2_1
X_08316_ count_cycle\[19\] count_cycle\[20\] _04090_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__and3_1
XANTENNA_30 _03577_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_41 clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_122_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08247_ _04044_ _04045_ net686 VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05459_ net25 net596 net588 VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__a21o_1
XANTENNA_63 net305 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_74 net487 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_52 net172 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_85 net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_96 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08178_ net557 _03983_ VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__nor2_1
XFILLER_134_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07129_ decoded_imm\[30\] net194 VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__or2_1
Xoutput170 net170 VGND VGND VPWR VPWR mem_wstrb[3] sky130_fd_sc_hd__buf_2
X_10140_ clknet_leaf_144_clk _00264_ VGND VGND VPWR VPWR cpuregs\[21\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput192 net192 VGND VGND VPWR VPWR pcpi_rs1[29] sky130_fd_sc_hd__buf_2
X_10071_ clknet_leaf_24_clk _00195_ VGND VGND VPWR VPWR cpuregs\[13\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xoutput181 net866 VGND VGND VPWR VPWR pcpi_rs1[19] sky130_fd_sc_hd__buf_2
XFILLER_0_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10973_ clknet_leaf_100_clk _01029_ VGND VGND VPWR VPWR decoded_imm\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_139_2558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_129_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_152_2758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_152_2769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11456_ clknet_leaf_55_clk _01494_ VGND VGND VPWR VPWR cpuregs\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_10407_ clknet_leaf_22_clk _00531_ VGND VGND VPWR VPWR cpuregs\[20\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_59_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11387_ clknet_leaf_5_clk _01425_ VGND VGND VPWR VPWR cpuregs\[7\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10338_ clknet_leaf_14_clk _00462_ VGND VGND VPWR VPWR cpuregs\[16\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10269_ clknet_leaf_139_clk _00393_ VGND VGND VPWR VPWR cpuregs\[15\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07480_ net1578 net289 net432 VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__mux2_1
X_06500_ _02923_ _02924_ net731 VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__mux2_1
X_06431_ net727 _02857_ _02861_ net638 _02853_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__o311a_1
XFILLER_148_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09150_ net550 _04769_ _04774_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__nor3_1
X_06362_ cpuregs\[24\]\[2\] cpuregs\[25\]\[2\] cpuregs\[26\]\[2\] cpuregs\[27\]\[2\]
+ net790 net753 VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__mux4_1
X_05313_ _01903_ _01904_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__nor2_1
X_08101_ _03895_ _03904_ _03911_ net685 VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__a31o_1
X_09081_ _04738_ _01096_ VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__and2b_1
X_06293_ _02726_ _02727_ net731 VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__mux2_1
X_05244_ _01829_ _01832_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__nand2_1
X_08032_ _03848_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__inv_2
Xhold801 cpuregs\[11\]\[17\] VGND VGND VPWR VPWR net1909 sky130_fd_sc_hd__dlygate4sd3_1
Xhold812 cpuregs\[19\]\[13\] VGND VGND VPWR VPWR net1920 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold823 cpuregs\[19\]\[20\] VGND VGND VPWR VPWR net1931 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold845 cpuregs\[7\]\[17\] VGND VGND VPWR VPWR net1953 sky130_fd_sc_hd__dlygate4sd3_1
X_05175_ net706 net202 _01774_ net702 _01777_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__a221o_1
Xhold834 cpuregs\[9\]\[3\] VGND VGND VPWR VPWR net1942 sky130_fd_sc_hd__dlygate4sd3_1
Xhold878 cpuregs\[5\]\[20\] VGND VGND VPWR VPWR net1986 sky130_fd_sc_hd__dlygate4sd3_1
Xmax_cap564 _02719_ VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__buf_1
Xhold867 cpuregs\[3\]\[13\] VGND VGND VPWR VPWR net1975 sky130_fd_sc_hd__dlygate4sd3_1
Xhold889 cpuregs\[8\]\[12\] VGND VGND VPWR VPWR net1997 sky130_fd_sc_hd__dlygate4sd3_1
X_09983_ clknet_leaf_149_clk _00107_ VGND VGND VPWR VPWR cpuregs\[12\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold856 cpuregs\[11\]\[7\] VGND VGND VPWR VPWR net1964 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_768 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08934_ net219 net632 _04607_ _04608_ VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__o22a_1
XFILLER_89_649 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_130_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08865_ cpuregs\[28\]\[21\] cpuregs\[29\]\[21\] cpuregs\[30\]\[21\] cpuregs\[31\]\[21\]
+ net964 net929 VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_123_2304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07816_ _03682_ _03683_ VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__nor2_1
X_08796_ cpuregs\[4\]\[17\] cpuregs\[5\]\[17\] cpuregs\[6\]\[17\] cpuregs\[7\]\[17\]
+ net958 net923 VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__mux4_1
X_07747_ count_instr\[30\] _03637_ count_instr\[31\] VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__a21o_1
XFILLER_84_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04959_ instr_sll net831 instr_add instr_andi VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__or4_1
X_07678_ count_instr\[5\] _03593_ count_instr\[6\] VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09417_ net299 net1776 net398 VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__mux2_1
X_06629_ cpuregs\[16\]\[11\] cpuregs\[17\]\[11\] cpuregs\[18\]\[11\] cpuregs\[19\]\[11\]
+ net773 net737 VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_101_1945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09348_ mem_rdata_q\[24\] net616 VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__and2_1
XFILLER_138_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_126_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11310_ clknet_leaf_114_clk _01351_ VGND VGND VPWR VPWR cpuregs\[5\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_09279_ net1153 net123 net486 VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__mux2_1
XFILLER_153_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_134_2477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11241_ clknet_leaf_70_clk _01282_ VGND VGND VPWR VPWR cpuregs\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_11172_ clknet_leaf_44_clk _01213_ VGND VGND VPWR VPWR cpuregs\[23\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_121_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10123_ clknet_leaf_23_clk _00247_ VGND VGND VPWR VPWR cpuregs\[28\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10054_ clknet_leaf_27_clk _00178_ VGND VGND VPWR VPWR cpuregs\[13\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_771 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10956_ clknet_leaf_93_clk _01012_ VGND VGND VPWR VPWR decoded_imm\[18\] sky130_fd_sc_hd__dfxtp_2
X_10887_ clknet_leaf_50_clk _00943_ VGND VGND VPWR VPWR cpuregs\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold108 net60 VGND VGND VPWR VPWR net1216 sky130_fd_sc_hd__dlygate4sd3_1
X_11439_ clknet_leaf_44_clk _01477_ VGND VGND VPWR VPWR cpuregs\[8\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_74_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold119 reg_next_pc\[2\] VGND VGND VPWR VPWR net1227 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_153_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06980_ cpuregs\[24\]\[24\] cpuregs\[25\]\[24\] cpuregs\[26\]\[24\] cpuregs\[27\]\[24\]
+ net804 net767 VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__mux4_1
XFILLER_85_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05931_ net696 net847 net233 net593 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__a22o_1
X_05862_ _02051_ _02055_ _02417_ _02052_ VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__a31o_1
X_08650_ cpuregs\[12\]\[9\] cpuregs\[13\]\[9\] cpuregs\[14\]\[9\] cpuregs\[15\]\[9\]
+ net942 net907 VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__mux4_1
XFILLER_39_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_105_2012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07601_ net1605 net474 net414 VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__mux2_1
XFILLER_81_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05793_ _02148_ _02152_ _02341_ _02356_ _02150_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__a311o_1
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08581_ net901 _04270_ _04269_ net659 VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__o211a_1
X_07532_ net528 net2168 net425 VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_85_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07463_ net1385 net534 net431 VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__mux2_1
X_06414_ net649 _02842_ _02844_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__a21o_1
X_09202_ net1156 _01101_ net331 VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__mux2_1
XFILLER_148_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09133_ net1175 net500 _04749_ _04767_ VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__a22o_1
X_07394_ _03559_ _03565_ VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__nor2_4
XFILLER_136_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06345_ net886 decoded_imm\[1\] VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__nand2_1
XFILLER_136_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09064_ net617 instr_rdcycle net717 VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__or3b_1
X_06276_ _02709_ _02710_ net647 VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__mux2_1
Xhold620 cpuregs\[25\]\[26\] VGND VGND VPWR VPWR net1728 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_135_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_116_2185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05227_ count_cycle\[13\] net620 net591 _01825_ VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__o211a_1
X_08015_ _03830_ _03833_ net559 VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__o21a_1
XFILLER_150_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold631 cpuregs\[23\]\[22\] VGND VGND VPWR VPWR net1739 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_116_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold653 cpuregs\[30\]\[31\] VGND VGND VPWR VPWR net1761 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05158_ net31 _01653_ _01654_ net17 _01761_ VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__o221a_1
Xhold642 cpuregs\[5\]\[3\] VGND VGND VPWR VPWR net1750 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold675 cpuregs\[4\]\[16\] VGND VGND VPWR VPWR net1783 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold697 cpuregs\[14\]\[15\] VGND VGND VPWR VPWR net1805 sky130_fd_sc_hd__dlygate4sd3_1
Xhold686 cpuregs\[29\]\[12\] VGND VGND VPWR VPWR net1794 sky130_fd_sc_hd__dlygate4sd3_1
Xhold664 cpuregs\[1\]\[9\] VGND VGND VPWR VPWR net1772 sky130_fd_sc_hd__dlygate4sd3_1
X_09966_ clknet_leaf_58_clk _00090_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dfxtp_1
X_05089_ net824 count_cycle\[35\] net622 _01697_ VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__a211o_1
XFILLER_131_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09897_ net1125 VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__clkbuf_1
X_08917_ cpuregs\[16\]\[24\] cpuregs\[17\]\[24\] cpuregs\[18\]\[24\] cpuregs\[19\]\[24\]
+ net967 net932 VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__mux4_1
XFILLER_57_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08848_ cpuregs\[4\]\[20\] cpuregs\[5\]\[20\] cpuregs\[6\]\[20\] cpuregs\[7\]\[20\]
+ net959 net924 VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_96_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_96_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_57_343 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08779_ cpuregs\[12\]\[16\] cpuregs\[13\]\[16\] cpuregs\[14\]\[16\] cpuregs\[15\]\[16\]
+ net967 net932 VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__mux4_1
X_10810_ clknet_leaf_98_clk _00869_ VGND VGND VPWR VPWR instr_srli sky130_fd_sc_hd__dfxtp_1
X_10741_ clknet_leaf_57_clk _00832_ VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dfxtp_2
XFILLER_41_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_136_2506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10672_ clknet_leaf_65_clk _04897_ VGND VGND VPWR VPWR reg_out\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_20_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_138_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11224_ clknet_leaf_5_clk _01265_ VGND VGND VPWR VPWR cpuregs\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11155_ clknet_leaf_146_clk _01196_ VGND VGND VPWR VPWR cpuregs\[23\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_8_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11086_ clknet_leaf_13_clk _01137_ VGND VGND VPWR VPWR cpuregs\[24\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_1_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10106_ clknet_leaf_116_clk _00230_ VGND VGND VPWR VPWR cpuregs\[28\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_147_2679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10037_ clknet_leaf_75_clk _00161_ VGND VGND VPWR VPWR cpuregs\[30\]\[29\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_87_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_87_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_847 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10939_ clknet_leaf_112_clk _00995_ VGND VGND VPWR VPWR latched_rd\[3\] sky130_fd_sc_hd__dfxtp_2
XFILLER_32_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_788 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_11_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_118_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06130_ reg_pc\[4\] reg_pc\[3\] reg_pc\[2\] VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__and3_1
X_06061_ net665 _02530_ VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__nand2_1
X_05012_ net835 net848 net603 _01628_ _01631_ VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__a311o_1
XFILLER_141_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout429 _03578_ VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__buf_4
X_09820_ net277 net2208 net351 VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__mux2_1
XFILLER_113_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout407 _04205_ VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__buf_4
Xfanout418 net419 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__clkbuf_8
X_09751_ net287 net2037 net359 VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__mux2_1
XFILLER_101_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06963_ net524 _03356_ _03360_ _03374_ net306 VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__o311a_1
X_05914_ _02099_ _02463_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__xnor2_1
X_08702_ cpuregs\[8\]\[12\] cpuregs\[9\]\[12\] cpuregs\[10\]\[12\] cpuregs\[11\]\[12\]
+ net946 net911 VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__mux4_1
X_06894_ net869 net509 net489 _03307_ VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__o211a_1
XFILLER_94_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_87_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09682_ net1736 net299 net366 VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__mux2_1
X_05845_ _02399_ _02402_ net693 VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__mux2_1
XFILLER_82_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08633_ cpuregs\[8\]\[8\] cpuregs\[9\]\[8\] cpuregs\[10\]\[8\] cpuregs\[11\]\[8\]
+ net944 net909 VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__mux4_1
XFILLER_82_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05776_ _02154_ _02157_ _02153_ VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__o21ba_1
X_08564_ decoded_imm\[4\] net601 net630 VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__o21ai_1
X_07515_ net1451 net281 net428 VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08495_ net79 net1208 net408 VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__mux2_1
XFILLER_50_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07446_ net1346 net293 net436 VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__mux2_1
XFILLER_10_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_118_2225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07377_ net302 net1632 net443 VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__mux2_1
XFILLER_13_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09116_ _04758_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__inv_2
X_06328_ cpuregs\[24\]\[1\] cpuregs\[25\]\[1\] net790 VGND VGND VPWR VPWR _02762_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_131_2425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09047_ cpuregs\[24\]\[31\] cpuregs\[25\]\[31\] cpuregs\[26\]\[31\] cpuregs\[27\]\[31\]
+ net962 net927 VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_98_1899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06259_ reg_pc\[28\] _02690_ reg_pc\[29\] VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__a21oi_1
Xhold461 cpuregs\[21\]\[6\] VGND VGND VPWR VPWR net1569 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold472 cpuregs\[18\]\[3\] VGND VGND VPWR VPWR net1580 sky130_fd_sc_hd__dlygate4sd3_1
Xhold450 cpuregs\[2\]\[0\] VGND VGND VPWR VPWR net1558 sky130_fd_sc_hd__dlygate4sd3_1
Xhold483 cpuregs\[23\]\[21\] VGND VGND VPWR VPWR net1591 sky130_fd_sc_hd__dlygate4sd3_1
Xhold494 cpuregs\[26\]\[1\] VGND VGND VPWR VPWR net1602 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout930 net932 VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__clkbuf_4
Xfanout952 _00007_ VGND VGND VPWR VPWR net952 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09949_ clknet_leaf_141_clk _00073_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dfxtp_1
Xfanout941 net942 VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__buf_4
Xclkbuf_leaf_69_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_69_clk sky130_fd_sc_hd__clkbuf_8
Xfanout974 net975 VGND VGND VPWR VPWR net974 sky130_fd_sc_hd__buf_4
Xfanout963 net964 VGND VGND VPWR VPWR net963 sky130_fd_sc_hd__buf_4
XFILLER_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout985 net989 VGND VGND VPWR VPWR net985 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1150 count_cycle\[28\] VGND VGND VPWR VPWR net2258 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout996 net999 VGND VGND VPWR VPWR net996 sky130_fd_sc_hd__buf_1
XFILLER_58_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1172 count_instr\[54\] VGND VGND VPWR VPWR net2280 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1161 count_cycle\[16\] VGND VGND VPWR VPWR net2269 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_73_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1194 instr_lhu VGND VGND VPWR VPWR net2302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1183 count_cycle\[34\] VGND VGND VPWR VPWR net2291 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_142_2598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10724_ clknet_leaf_15_clk _00815_ VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dfxtp_2
XFILLER_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10655_ clknet_leaf_132_clk _04910_ VGND VGND VPWR VPWR reg_out\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_139_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xpicorv32_1090 VGND VGND VPWR VPWR picorv32_1090/HI trace_data[18] sky130_fd_sc_hd__conb_1
Xclkload17 clknet_leaf_5_clk VGND VGND VPWR VPWR clkload17/Y sky130_fd_sc_hd__clkinv_4
XFILLER_126_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload28 clknet_leaf_14_clk VGND VGND VPWR VPWR clkload28/Y sky130_fd_sc_hd__bufinv_16
Xclkload39 clknet_leaf_149_clk VGND VGND VPWR VPWR clkload39/X sky130_fd_sc_hd__clkbuf_8
X_10586_ clknet_leaf_112_clk _00710_ VGND VGND VPWR VPWR count_cycle\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_114_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_149_2708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_149_2719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11207_ clknet_leaf_51_clk _01248_ VGND VGND VPWR VPWR cpuregs\[29\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11138_ clknet_leaf_35_clk _01179_ VGND VGND VPWR VPWR cpuregs\[31\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_736 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11069_ clknet_leaf_99_clk _01120_ VGND VGND VPWR VPWR mem_rdata_q\[26\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_0_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_69_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05630_ net216 net862 VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__and2b_1
XFILLER_63_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05561_ net878 net844 VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__or2_1
X_07300_ net1878 net475 net450 VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__mux2_1
X_05492_ _02069_ _02071_ VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__nand2_1
XFILLER_60_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08280_ _04070_ _04071_ VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__nor2_1
X_07231_ net1934 net533 net459 VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__mux2_1
XFILLER_118_613 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07162_ net1624 net529 net467 VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__mux2_1
XFILLER_118_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06113_ latched_rd\[1\] latched_rd\[0\] _02579_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__nand3_4
X_07093_ cpuregs\[12\]\[28\] cpuregs\[13\]\[28\] cpuregs\[14\]\[28\] cpuregs\[15\]\[28\]
+ net805 net768 VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_113_2144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_307 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06044_ decoded_imm_j\[19\] _01113_ net332 VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__mux2_1
Xfanout237 _02708_ VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_2
XFILLER_99_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09803_ net492 net1911 net350 VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__mux2_1
Xfanout248 net249 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__clkbuf_1
XFILLER_140_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout259 _02684_ VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__clkbuf_2
XFILLER_75_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07995_ decoded_imm_j\[10\] _03706_ VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__nand2_1
XFILLER_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_568 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06946_ net866 net511 net490 _03357_ VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__o211a_1
X_09734_ net536 net1672 net358 VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__mux2_1
XFILLER_28_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06877_ _03283_ _03284_ net653 VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__mux2_1
X_09665_ latched_rd\[3\] latched_rd\[4\] latched_rd\[2\] VGND VGND VPWR VPWR _04873_
+ sky130_fd_sc_hd__or3b_2
X_05828_ _02386_ _02387_ net829 VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__mux2_1
X_08616_ _04302_ _04303_ net669 VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__mux2_1
XFILLER_28_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09596_ net1281 net244 net379 VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__mux2_1
X_05759_ _02159_ _02326_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__or2_1
X_08547_ cpuregs\[16\]\[1\] cpuregs\[17\]\[1\] cpuregs\[18\]\[1\] cpuregs\[19\]\[1\]
+ net955 net920 VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__mux4_1
X_08478_ net92 net1192 net406 VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__mux2_1
X_07429_ net2093 net540 net434 VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__mux2_1
X_10440_ clknet_leaf_44_clk _00564_ VGND VGND VPWR VPWR cpuregs\[17\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_148_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10371_ clknet_leaf_13_clk _00495_ VGND VGND VPWR VPWR cpuregs\[25\]\[11\] sky130_fd_sc_hd__dfxtp_1
Xhold280 cpuregs\[29\]\[23\] VGND VGND VPWR VPWR net1388 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold291 cpuregs\[27\]\[3\] VGND VGND VPWR VPWR net1399 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout760 net761 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_144_2638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout771 net772 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__buf_2
XFILLER_93_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout793 net796 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__clkbuf_4
Xfanout782 net784 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__buf_4
XFILLER_86_791 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10707_ clknet_leaf_82_clk _00799_ VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dfxtp_1
XFILLER_128_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload128 clknet_leaf_70_clk VGND VGND VPWR VPWR clkload128/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_139_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10638_ clknet_leaf_83_clk _00762_ VGND VGND VPWR VPWR count_cycle\[55\] sky130_fd_sc_hd__dfxtp_1
Xclkload117 clknet_leaf_110_clk VGND VGND VPWR VPWR clkload117/Y sky130_fd_sc_hd__inv_6
Xclkload106 clknet_leaf_130_clk VGND VGND VPWR VPWR clkload106/Y sky130_fd_sc_hd__clkinv_8
XFILLER_127_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload139 clknet_leaf_89_clk VGND VGND VPWR VPWR clkload139/X sky130_fd_sc_hd__clkbuf_8
X_10569_ clknet_leaf_94_clk _00693_ VGND VGND VPWR VPWR reg_next_pc\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_127_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06800_ net868 _03217_ net306 VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__mux2_1
XFILLER_68_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07780_ count_instr\[43\] count_instr\[42\] _03657_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__and3_1
X_04992_ _01616_ _01611_ _01607_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__or3b_1
XFILLER_56_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06731_ cpuregs\[12\]\[15\] cpuregs\[13\]\[15\] cpuregs\[14\]\[15\] cpuregs\[15\]\[15\]
+ net783 net747 VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__mux4_1
Xinput4 mem_rdata[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__dlymetal6s2s_1
X_09450_ net299 net1976 net394 VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__mux2_1
X_08401_ _04146_ _04147_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__nor2_1
XFILLER_64_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06662_ _03081_ _03082_ net646 VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__mux2_1
XFILLER_25_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06593_ net876 net507 _02940_ net495 VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__o211a_1
X_09381_ net833 decoded_imm_j\[8\] _04826_ mem_rdata_q\[28\] net551 VGND VGND VPWR
+ VPWR _04853_ sky130_fd_sc_hd__a221o_1
XFILLER_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05613_ _02180_ _02192_ _02181_ VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__o21a_1
XFILLER_40_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08332_ count_cycle\[25\] count_cycle\[26\] _04100_ VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__and3_1
X_05544_ _02122_ _02123_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_35_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08263_ net1001 _04061_ VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__and2_1
XFILLER_60_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05475_ net861 net217 VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__nand2_1
X_07214_ net1821 net284 net463 VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__mux2_1
X_08194_ _03997_ _03998_ net1002 VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__o21a_1
XFILLER_118_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_146_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07145_ cpuregs\[20\]\[30\] cpuregs\[21\]\[30\] cpuregs\[22\]\[30\] cpuregs\[23\]\[30\]
+ net807 net770 VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_95_1847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07076_ _03430_ _03452_ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_95_1858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06027_ mem_rdata_q\[21\] net14 net611 VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__mux2_1
XFILLER_133_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_120_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_660 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_102_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07978_ net559 _03798_ _03799_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__a21o_1
X_06929_ cpuregs\[8\]\[22\] cpuregs\[9\]\[22\] cpuregs\[10\]\[22\] cpuregs\[11\]\[22\]
+ net798 net761 VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_126_2346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09717_ net291 net2039 net363 VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__mux2_1
XFILLER_67_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09648_ net300 net2088 net370 VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__mux2_1
X_09579_ net1794 net319 net377 VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__mux2_1
XFILLER_31_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11472_ clknet_leaf_138_clk _01510_ VGND VGND VPWR VPWR cpuregs\[10\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_137_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10423_ clknet_leaf_23_clk _00547_ VGND VGND VPWR VPWR cpuregs\[20\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_10354_ clknet_leaf_50_clk _00478_ VGND VGND VPWR VPWR cpuregs\[16\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_137_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10285_ clknet_leaf_36_clk _00409_ VGND VGND VPWR VPWR cpuregs\[15\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout590 net591 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__buf_2
XFILLER_74_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05260_ _01807_ _01818_ VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__nand2b_1
X_05191_ _01789_ _01790_ VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_77_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08950_ net894 _04622_ net667 VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__a21o_1
XFILLER_115_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08881_ cpuregs\[12\]\[22\] cpuregs\[13\]\[22\] cpuregs\[14\]\[22\] cpuregs\[15\]\[22\]
+ net964 net929 VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07901_ _01629_ _03729_ VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__or2_1
X_07832_ _03692_ _03693_ VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__nor2_1
XFILLER_97_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_97_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_108_2065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04975_ net850 net851 mem_do_rinst _01572_ net611 VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__o311a_1
X_09502_ net1410 net536 net386 VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__mux2_1
X_07763_ count_instr\[36\] _03647_ count_instr\[37\] VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__a21o_1
XFILLER_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06714_ _03131_ _03132_ _03133_ _03134_ net728 net639 VGND VGND VPWR VPWR _03135_
+ sky130_fd_sc_hd__mux4_2
X_07694_ count_instr\[11\] _03603_ count_instr\[12\] VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__a21o_1
XFILLER_24_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09433_ net236 net2110 net398 VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__mux2_1
XFILLER_92_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06645_ _02959_ _02963_ _02985_ _02986_ _03067_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__a311o_1
XTAP_TAPCELL_ROW_121_2265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09364_ net837 decoded_imm_j\[16\] net615 mem_rdata_q\[16\] VGND VGND VPWR VPWR _04844_
+ sky130_fd_sc_hd__a22o_1
XFILLER_52_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08315_ count_cycle\[19\] _04090_ count_cycle\[20\] VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__a21o_1
X_06576_ cpuregs\[16\]\[9\] cpuregs\[17\]\[9\] cpuregs\[18\]\[9\] cpuregs\[19\]\[9\]
+ net773 net737 VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__mux4_1
XFILLER_40_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_31 _03577_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05527_ _02105_ _02106_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__or2_1
X_09295_ net1152 net109 net484 VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__mux2_1
XFILLER_21_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_20 _02955_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08246_ net814 _03727_ _04044_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__o21a_1
X_05458_ _02038_ net715 _02037_ VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__and3b_1
XANTENNA_75 net522 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_64 net350 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_42 mem_rdata_q\[24\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_53 net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_118_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08177_ net837 _03981_ _03982_ _03980_ VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__o31a_1
XANTENNA_86 net772 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_97 net874 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_134_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05389_ reg_pc\[26\] decoded_imm\[26\] VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__nand2_1
X_07128_ decoded_imm\[30\] net194 VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__nand2_1
XFILLER_137_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07059_ cpuregs\[20\]\[27\] cpuregs\[21\]\[27\] cpuregs\[22\]\[27\] cpuregs\[23\]\[27\]
+ net808 net771 VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__mux4_1
XFILLER_79_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput160 net160 VGND VGND VPWR VPWR mem_wdata[3] sky130_fd_sc_hd__buf_2
XFILLER_0_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10070_ clknet_leaf_80_clk _00194_ VGND VGND VPWR VPWR cpuregs\[13\]\[30\] sky130_fd_sc_hd__dfxtp_1
Xoutput193 net193 VGND VGND VPWR VPWR pcpi_rs1[2] sky130_fd_sc_hd__buf_2
Xoutput182 net182 VGND VGND VPWR VPWR pcpi_rs1[1] sky130_fd_sc_hd__buf_2
Xoutput171 net171 VGND VGND VPWR VPWR pcpi_rs1[0] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_48_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10972_ clknet_leaf_130_clk _01028_ VGND VGND VPWR VPWR decoded_imm\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11455_ clknet_leaf_17_clk _01493_ VGND VGND VPWR VPWR cpuregs\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_152_2759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10406_ clknet_leaf_9_clk _00530_ VGND VGND VPWR VPWR cpuregs\[20\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11386_ clknet_leaf_13_clk _01424_ VGND VGND VPWR VPWR cpuregs\[7\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10337_ clknet_leaf_1_clk _00461_ VGND VGND VPWR VPWR cpuregs\[16\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10268_ clknet_leaf_143_clk _00392_ VGND VGND VPWR VPWR cpuregs\[15\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_72_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10199_ clknet_leaf_44_clk _00323_ VGND VGND VPWR VPWR cpuregs\[9\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_37_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06430_ _02858_ _02859_ _02860_ net749 net733 VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__o221a_1
XFILLER_34_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06361_ net723 _02789_ _02791_ _02793_ net643 VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__o221a_1
XFILLER_148_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05312_ _01890_ _01893_ _01891_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__o21a_1
X_08100_ _03895_ _03904_ _03911_ VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__a21oi_1
X_09080_ mem_rdata_q\[2\] net23 net614 VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__mux2_1
X_06292_ cpuregs\[20\]\[0\] cpuregs\[21\]\[0\] cpuregs\[22\]\[0\] cpuregs\[23\]\[0\]
+ net776 net740 VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__mux4_1
X_05243_ _01838_ _01839_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__and2b_1
X_08031_ _03825_ _03836_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__nand2_1
Xhold802 cpuregs\[12\]\[26\] VGND VGND VPWR VPWR net1910 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold846 cpuregs\[18\]\[25\] VGND VGND VPWR VPWR net1954 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_115_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold835 cpuregs\[1\]\[14\] VGND VGND VPWR VPWR net1943 sky130_fd_sc_hd__dlygate4sd3_1
X_05174_ count_cycle\[9\] net621 net592 _01776_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_55_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold813 cpuregs\[16\]\[4\] VGND VGND VPWR VPWR net1921 sky130_fd_sc_hd__dlygate4sd3_1
Xhold824 cpuregs\[17\]\[6\] VGND VGND VPWR VPWR net1932 sky130_fd_sc_hd__dlygate4sd3_1
Xhold857 cpuregs\[22\]\[25\] VGND VGND VPWR VPWR net1965 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_107_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold879 cpuregs\[30\]\[18\] VGND VGND VPWR VPWR net1987 sky130_fd_sc_hd__dlygate4sd3_1
Xhold868 cpuregs\[19\]\[15\] VGND VGND VPWR VPWR net1976 sky130_fd_sc_hd__dlygate4sd3_1
X_09982_ clknet_leaf_142_clk _00106_ VGND VGND VPWR VPWR cpuregs\[12\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_08933_ decoded_imm\[24\] net599 net627 VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__a21o_1
XFILLER_103_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08864_ cpuregs\[16\]\[21\] cpuregs\[17\]\[21\] cpuregs\[18\]\[21\] cpuregs\[19\]\[21\]
+ net963 net928 VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_123_2305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07815_ net2251 _03681_ net998 VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__o21ai_1
X_08795_ cpuregs\[24\]\[17\] cpuregs\[25\]\[17\] cpuregs\[26\]\[17\] cpuregs\[27\]\[17\]
+ net958 net923 VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__mux4_1
XFILLER_57_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07746_ net2303 _03637_ _03639_ VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__a21oi_1
XFILLER_83_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_04958_ instr_sw instr_sh _01577_ _01584_ VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__or4_1
XFILLER_44_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09416_ net308 net1989 net398 VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__mux2_1
X_07677_ net2272 _03593_ _03595_ VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__a21oi_1
XFILLER_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06628_ cpuregs\[24\]\[11\] cpuregs\[25\]\[11\] cpuregs\[26\]\[11\] cpuregs\[27\]\[11\]
+ net779 net743 VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__mux4_1
XFILLER_138_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_101_1946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09347_ decoded_imm\[25\] net553 net401 _04835_ VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__o22a_1
X_06559_ decoded_imm\[9\] net876 VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__nand2_1
XFILLER_8_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09278_ net1143 net122 net486 VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__mux2_1
X_08229_ net690 reg_next_pc\[28\] net547 _03725_ VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__a22o_1
XFILLER_20_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_73_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11240_ clknet_leaf_69_clk _01281_ VGND VGND VPWR VPWR cpuregs\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_134_2478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11171_ clknet_leaf_43_clk _01212_ VGND VGND VPWR VPWR cpuregs\[23\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10122_ clknet_leaf_24_clk _00246_ VGND VGND VPWR VPWR cpuregs\[28\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10053_ clknet_leaf_10_clk _00177_ VGND VGND VPWR VPWR cpuregs\[13\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_91_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_82_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10955_ clknet_leaf_93_clk _01011_ VGND VGND VPWR VPWR decoded_imm\[19\] sky130_fd_sc_hd__dfxtp_2
XFILLER_73_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10886_ clknet_leaf_53_clk _00942_ VGND VGND VPWR VPWR cpuregs\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_91_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_145_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold109 cpuregs\[24\]\[28\] VGND VGND VPWR VPWR net1217 sky130_fd_sc_hd__dlygate4sd3_1
X_11438_ clknet_leaf_74_clk _01476_ VGND VGND VPWR VPWR cpuregs\[8\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_74_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11369_ clknet_leaf_68_clk _01407_ VGND VGND VPWR VPWR cpuregs\[6\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05930_ net697 net847 net233 net694 VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__a22o_1
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05861_ _02401_ _02415_ _02416_ _02058_ VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_105_2013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07600_ net1546 net493 net417 VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__mux2_1
X_08580_ _04262_ _04263_ net670 VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__mux2_1
X_05792_ net871 net209 _02146_ _02342_ _02147_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__o221a_1
X_07531_ net533 net1928 net425 VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__mux2_1
XFILLER_35_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_85_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07462_ net1419 net539 net430 VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__mux2_1
X_07393_ net237 net2072 net444 VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__mux2_1
X_09201_ mem_rdata_q\[7\] net30 net611 VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__mux2_1
XFILLER_50_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06413_ net733 _02843_ net727 VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__a21o_1
X_09132_ net976 is_alu_reg_imm net555 VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__and3_2
X_06344_ net886 decoded_imm\[1\] VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_20_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09063_ net712 _04729_ VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_20_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06275_ cpuregs\[0\]\[0\] cpuregs\[1\]\[0\] cpuregs\[2\]\[0\] cpuregs\[3\]\[0\] net782
+ net746 VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__mux4_1
XFILLER_151_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_2186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold621 cpuregs\[1\]\[18\] VGND VGND VPWR VPWR net1729 sky130_fd_sc_hd__dlygate4sd3_1
X_05226_ net827 count_cycle\[45\] net625 _01824_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__a211o_1
X_08014_ net832 _03831_ _03832_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__nor3_1
Xhold610 cpuregs\[9\]\[11\] VGND VGND VPWR VPWR net1718 sky130_fd_sc_hd__dlygate4sd3_1
Xhold643 cpuregs\[15\]\[27\] VGND VGND VPWR VPWR net1751 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05157_ _01546_ latched_is_lh net593 VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__o21a_1
Xhold654 cpuregs\[6\]\[3\] VGND VGND VPWR VPWR net1762 sky130_fd_sc_hd__dlygate4sd3_1
Xhold632 cpuregs\[10\]\[2\] VGND VGND VPWR VPWR net1740 sky130_fd_sc_hd__dlygate4sd3_1
Xhold687 cpuregs\[13\]\[20\] VGND VGND VPWR VPWR net1795 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold665 cpuregs\[26\]\[17\] VGND VGND VPWR VPWR net1773 sky130_fd_sc_hd__dlygate4sd3_1
Xhold676 cpuregs\[14\]\[19\] VGND VGND VPWR VPWR net1784 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_139_Left_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09965_ clknet_leaf_58_clk _00089_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dfxtp_2
XFILLER_77_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05088_ count_instr\[35\] net815 net819 count_instr\[3\] VGND VGND VPWR VPWR _01697_
+ sky130_fd_sc_hd__a22o_1
Xhold698 cpuregs\[3\]\[0\] VGND VGND VPWR VPWR net1806 sky130_fd_sc_hd__dlygate4sd3_1
X_09896_ net1135 VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__clkbuf_1
X_08916_ cpuregs\[20\]\[24\] cpuregs\[21\]\[24\] cpuregs\[22\]\[24\] cpuregs\[23\]\[24\]
+ net961 net926 VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__mux4_1
XFILLER_97_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08847_ cpuregs\[24\]\[20\] cpuregs\[25\]\[20\] cpuregs\[26\]\[20\] cpuregs\[27\]\[20\]
+ net963 net928 VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__mux4_1
XFILLER_94_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_355 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08778_ net903 _04460_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__or2_1
X_07729_ net2364 _03626_ net997 VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__o21ai_1
XFILLER_41_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10740_ clknet_leaf_65_clk _00831_ VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dfxtp_4
XFILLER_13_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_139_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10671_ clknet_leaf_65_clk _04896_ VGND VGND VPWR VPWR reg_out\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_136_2507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_127_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11223_ clknet_leaf_12_clk _01264_ VGND VGND VPWR VPWR cpuregs\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_56_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_56_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11154_ clknet_leaf_149_clk _01195_ VGND VGND VPWR VPWR cpuregs\[23\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_11085_ clknet_leaf_15_clk _01136_ VGND VGND VPWR VPWR cpuregs\[24\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10105_ clknet_leaf_114_clk _00229_ VGND VGND VPWR VPWR cpuregs\[28\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_10036_ clknet_leaf_75_clk _00160_ VGND VGND VPWR VPWR cpuregs\[30\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10938_ clknet_leaf_112_clk _00994_ VGND VGND VPWR VPWR latched_rd\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_32_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10869_ clknet_leaf_152_clk _00925_ VGND VGND VPWR VPWR cpuregs\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_31_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_145_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_133_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06060_ _02528_ _02529_ net675 VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__mux2_1
XFILLER_126_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05011_ net691 net849 VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__nor2_4
XFILLER_113_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout408 _04205_ VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkbuf_8
Xfanout419 _03581_ VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__buf_4
XFILLER_141_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06962_ reg_pc\[23\] net561 _03373_ net518 net521 VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__a221o_1
X_09750_ net291 net2109 net359 VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__mux2_1
X_05913_ _02461_ _02462_ net830 VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__mux2_1
X_09681_ net1506 net308 net365 VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__mux2_1
XFILLER_67_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08701_ cpuregs\[24\]\[12\] cpuregs\[25\]\[12\] cpuregs\[26\]\[12\] cpuregs\[27\]\[12\]
+ net947 net912 VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__mux4_1
XFILLER_39_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06893_ net857 net513 VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_87_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08632_ net670 _04322_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__or2_1
X_05844_ _02386_ _02400_ _02401_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__o21a_1
XFILLER_82_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05775_ _02155_ _02159_ _02325_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__and3_1
XFILLER_70_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08563_ _02527_ _02567_ _02575_ _01639_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__o31a_1
X_08494_ net78 net1213 net408 VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__mux2_1
XFILLER_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07514_ net1827 net284 net428 VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07445_ net2028 net297 net436 VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__mux2_1
XFILLER_23_767 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07376_ net310 net2016 net442 VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__mux2_1
XFILLER_136_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09115_ _01108_ _01107_ _01106_ _04739_ VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__or4b_1
XFILLER_13_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06327_ net788 cpuregs\[26\]\[1\] VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__and2b_1
XFILLER_135_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06258_ reg_out\[29\] alu_out_q\[29\] net843 VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__mux2_1
X_09046_ cpuregs\[28\]\[31\] cpuregs\[29\]\[31\] cpuregs\[30\]\[31\] cpuregs\[31\]\[31\]
+ net962 net927 VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__mux4_1
XFILLER_89_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_131_2426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05209_ _01805_ _01808_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_147_Left_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold440 cpuregs\[27\]\[27\] VGND VGND VPWR VPWR net1548 sky130_fd_sc_hd__dlygate4sd3_1
Xhold451 cpuregs\[29\]\[16\] VGND VGND VPWR VPWR net1559 sky130_fd_sc_hd__dlygate4sd3_1
Xhold462 cpuregs\[31\]\[18\] VGND VGND VPWR VPWR net1570 sky130_fd_sc_hd__dlygate4sd3_1
X_06189_ _02639_ _02640_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__nor2_1
XFILLER_145_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold495 cpuregs\[21\]\[20\] VGND VGND VPWR VPWR net1603 sky130_fd_sc_hd__dlygate4sd3_1
Xhold484 cpuregs\[26\]\[13\] VGND VGND VPWR VPWR net1592 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold473 cpuregs\[27\]\[4\] VGND VGND VPWR VPWR net1581 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout931 net932 VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__clkbuf_4
XFILLER_131_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout920 net922 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__clkbuf_4
Xfanout942 net952 VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__buf_4
X_09948_ clknet_leaf_132_clk _00072_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dfxtp_2
Xfanout975 _00007_ VGND VGND VPWR VPWR net975 sky130_fd_sc_hd__clkbuf_4
Xfanout964 net968 VGND VGND VPWR VPWR net964 sky130_fd_sc_hd__buf_4
Xfanout986 net989 VGND VGND VPWR VPWR net986 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_51_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout953 net954 VGND VGND VPWR VPWR net953 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_129_2399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout997 net999 VGND VGND VPWR VPWR net997 sky130_fd_sc_hd__clkbuf_2
Xhold1140 count_cycle\[15\] VGND VGND VPWR VPWR net2248 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1151 count_instr\[13\] VGND VGND VPWR VPWR net2259 sky130_fd_sc_hd__dlygate4sd3_1
X_09879_ net1111 VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__clkbuf_1
XFILLER_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1162 count_cycle\[54\] VGND VGND VPWR VPWR net2270 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1184 count_cycle\[12\] VGND VGND VPWR VPWR net2292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1173 count_instr\[7\] VGND VGND VPWR VPWR net2281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1195 count_instr\[30\] VGND VGND VPWR VPWR net2303 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_33_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_142_2599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10723_ clknet_leaf_15_clk _00814_ VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dfxtp_2
XFILLER_54_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_778 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10654_ clknet_leaf_127_clk _04909_ VGND VGND VPWR VPWR reg_out\[6\] sky130_fd_sc_hd__dfxtp_1
Xpicorv32_1080 VGND VGND VPWR VPWR picorv32_1080/HI trace_data[8] sky130_fd_sc_hd__conb_1
Xpicorv32_1091 VGND VGND VPWR VPWR picorv32_1091/HI trace_data[19] sky130_fd_sc_hd__conb_1
X_10585_ clknet_leaf_111_clk _00709_ VGND VGND VPWR VPWR count_cycle\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload29 clknet_leaf_16_clk VGND VGND VPWR VPWR clkload29/Y sky130_fd_sc_hd__inv_8
Xclkload18 clknet_leaf_152_clk VGND VGND VPWR VPWR clkload18/X sky130_fd_sc_hd__clkbuf_8
XFILLER_127_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_149_2709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11206_ clknet_leaf_66_clk _01247_ VGND VGND VPWR VPWR cpuregs\[29\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11137_ clknet_leaf_35_clk _01178_ VGND VGND VPWR VPWR cpuregs\[31\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_68_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11068_ clknet_leaf_99_clk _01119_ VGND VGND VPWR VPWR mem_rdata_q\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_69_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10019_ clknet_leaf_3_clk _00143_ VGND VGND VPWR VPWR cpuregs\[30\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_24_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05560_ net878 net844 VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05491_ net865 net213 VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__or2_1
XFILLER_60_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07230_ net1368 net534 net459 VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__mux2_1
XFILLER_118_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07161_ net1835 net533 net467 VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__mux2_1
X_06112_ latched_branch latched_store net603 VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__o21a_2
X_07092_ cpuregs\[16\]\[28\] cpuregs\[17\]\[28\] cpuregs\[18\]\[28\] cpuregs\[19\]\[28\]
+ net805 net768 VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_113_2134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_113_2145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_319 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06043_ net2346 net11 net614 VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__mux2_1
XFILLER_5_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout238 _02708_ VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_2
XFILLER_87_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09802_ net529 net2071 net350 VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__mux2_1
Xfanout249 net250 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_2
X_07994_ _03706_ _03802_ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__xnor2_1
X_06945_ net855 net514 VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__or2_1
X_09733_ net538 net2058 net358 VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__mux2_1
XFILLER_131_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06876_ _03287_ _03288_ net653 VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__mux2_1
X_09664_ net238 net2223 net370 VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__mux2_1
XFILLER_67_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09595_ net1223 net250 net379 VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__mux2_1
X_05827_ _02077_ _02373_ _02217_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__a21o_1
X_08615_ net899 _04299_ net889 VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__o21a_1
XFILLER_54_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05758_ _02320_ _02325_ net692 VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__mux2_1
X_08546_ cpuregs\[20\]\[1\] cpuregs\[21\]\[1\] cpuregs\[22\]\[1\] cpuregs\[23\]\[1\]
+ net955 net920 VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__mux4_1
XFILLER_51_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05689_ net828 _02264_ _02265_ VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__o21a_1
X_08477_ net91 net1216 net406 VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__mux2_1
XFILLER_24_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07428_ latched_rd\[1\] latched_rd\[0\] _03575_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__and3_2
XFILLER_149_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07359_ net2020 net240 net448 VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_149_Right_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10370_ clknet_leaf_15_clk _00494_ VGND VGND VPWR VPWR cpuregs\[25\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_09029_ cpuregs\[28\]\[30\] cpuregs\[29\]\[30\] cpuregs\[30\]\[30\] cpuregs\[31\]\[30\]
+ net974 net939 VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__mux4_1
XFILLER_151_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold270 cpuregs\[14\]\[10\] VGND VGND VPWR VPWR net1378 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 cpuregs\[26\]\[26\] VGND VGND VPWR VPWR net1400 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold281 cpuregs\[17\]\[4\] VGND VGND VPWR VPWR net1389 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_131_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout750 net751 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_144_2639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout772 _00013_ VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__buf_4
XFILLER_120_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout761 net765 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__clkbuf_4
Xfanout794 net796 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__buf_2
XFILLER_93_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout783 net784 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__buf_2
XFILLER_77_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_110 net734 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_14_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10706_ clknet_4_15_0_clk _00798_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dfxtp_1
Xclkload118 clknet_leaf_60_clk VGND VGND VPWR VPWR clkload118/Y sky130_fd_sc_hd__clkinvlp_4
X_10637_ clknet_leaf_83_clk _00761_ VGND VGND VPWR VPWR count_cycle\[54\] sky130_fd_sc_hd__dfxtp_1
Xclkload107 clknet_leaf_97_clk VGND VGND VPWR VPWR clkload107/Y sky130_fd_sc_hd__clkinv_4
XFILLER_10_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload129 clknet_leaf_71_clk VGND VGND VPWR VPWR clkload129/Y sky130_fd_sc_hd__clkinv_4
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10568_ clknet_leaf_60_clk _00692_ VGND VGND VPWR VPWR reg_next_pc\[17\] sky130_fd_sc_hd__dfxtp_1
X_10499_ clknet_leaf_106_clk _00623_ VGND VGND VPWR VPWR count_instr\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_68_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04991_ net850 cpu_state\[5\] _01605_ _01615_ VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__a31o_1
X_06730_ cpuregs\[16\]\[15\] cpuregs\[17\]\[15\] cpuregs\[18\]\[15\] cpuregs\[19\]\[15\]
+ net783 net747 VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__mux4_1
Xinput5 mem_rdata[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_2
X_06661_ _03075_ _03076_ net646 VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__mux2_1
X_08400_ net2253 _04144_ net996 VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__o21ai_1
X_05612_ _02166_ _02191_ _02182_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__a21o_1
XFILLER_18_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06592_ net872 net513 VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__or2_1
X_09380_ decoded_imm\[9\] net552 _04852_ VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__o21a_1
XFILLER_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08331_ count_cycle\[25\] _04100_ count_cycle\[26\] VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__a21o_1
X_05543_ net875 net204 VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__nor2_1
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05474_ _02051_ _02053_ VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__nand2_2
X_08262_ _03585_ _04059_ _04060_ VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__a21o_1
XFILLER_60_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07213_ net1987 net289 net463 VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__mux2_1
X_08193_ net690 reg_next_pc\[25\] net547 _03722_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__a22o_1
X_07144_ cpuregs\[0\]\[30\] cpuregs\[1\]\[30\] cpuregs\[2\]\[30\] cpuregs\[3\]\[30\]
+ net807 net770 VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__mux4_1
XFILLER_146_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07075_ _03380_ _03404_ _03405_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_95_1859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06026_ decoded_imm_j\[11\] _01114_ net331 VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__mux2_1
XFILLER_126_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_672 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07977_ net688 reg_next_pc\[8\] net545 _03704_ VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__a22o_1
X_06928_ cpuregs\[12\]\[22\] cpuregs\[13\]\[22\] cpuregs\[14\]\[22\] cpuregs\[15\]\[22\]
+ net798 net761 VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_126_2347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09716_ net295 net1477 net364 VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__mux2_1
XFILLER_101_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06859_ decoded_imm\[20\] net864 VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__and2_1
X_09647_ net308 net2060 net370 VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__mux2_1
XFILLER_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09578_ net1239 _02626_ net377 VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_46_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08529_ cpuregs\[28\]\[0\] cpuregs\[29\]\[0\] cpuregs\[30\]\[0\] cpuregs\[31\]\[0\]
+ net950 net915 VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_104_1999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_136_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11471_ clknet_leaf_24_clk _01509_ VGND VGND VPWR VPWR cpuregs\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10422_ clknet_leaf_74_clk _00546_ VGND VGND VPWR VPWR cpuregs\[20\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_137_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10353_ clknet_leaf_67_clk _00477_ VGND VGND VPWR VPWR cpuregs\[16\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10284_ clknet_leaf_36_clk _00408_ VGND VGND VPWR VPWR cpuregs\[15\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout580 _02244_ VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__buf_2
Xfanout591 net592 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__clkbuf_4
XFILLER_78_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_61_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05190_ _01790_ VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__inv_2
XFILLER_115_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08880_ net216 net632 _04556_ _04557_ VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_102_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_90_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07900_ decoded_imm_j\[1\] _03695_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__nand2_1
X_07831_ net2308 _03691_ net1000 VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_90_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04974_ net33 net134 VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__nand2_1
X_07762_ net2285 _03647_ _03649_ VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__a21oi_1
X_09501_ net1683 _02584_ net386 VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__mux2_1
X_06713_ _03125_ _03126_ net651 VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__mux2_1
X_07693_ net2297 _03603_ _03605_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__a21oi_1
X_09432_ net239 net2178 net399 VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__mux2_1
X_06644_ _03013_ _03040_ _03041_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_121_2266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09363_ net2378 net553 _04827_ _04843_ VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__o22a_1
X_06575_ cpuregs\[20\]\[9\] cpuregs\[21\]\[9\] cpuregs\[22\]\[9\] cpuregs\[23\]\[9\]
+ net774 net738 VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__mux4_1
XFILLER_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_111_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05526_ net856 net221 VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__nor2_1
X_08314_ net2250 _04090_ _04092_ VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_32 _04264_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_21 _03295_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09294_ net2325 net107 net484 VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__mux2_1
XANTENNA_10 _01837_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08245_ net814 _03727_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__xor2_1
X_05457_ _02024_ _02027_ _02036_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__and3_1
XANTENNA_43 reg_out\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_65 net362 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_54 net177 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_153_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08176_ _03721_ _03972_ VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__and2b_1
XANTENNA_87 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05388_ reg_pc\[26\] decoded_imm\[26\] VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__or2_1
XANTENNA_76 net584 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_98 net879 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_119_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07127_ net853 _03532_ net307 VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__mux2_1
XFILLER_137_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07058_ cpuregs\[16\]\[27\] cpuregs\[17\]\[27\] cpuregs\[18\]\[27\] cpuregs\[19\]\[27\]
+ net808 net771 VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_120_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput150 net150 VGND VGND VPWR VPWR mem_wdata[23] sky130_fd_sc_hd__buf_2
XFILLER_79_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput161 net161 VGND VGND VPWR VPWR mem_wdata[4] sky130_fd_sc_hd__buf_2
X_06009_ reg_out\[25\] reg_next_pc\[25\] net573 VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__mux2_1
XFILLER_102_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput194 net194 VGND VGND VPWR VPWR pcpi_rs1[30] sky130_fd_sc_hd__buf_2
Xoutput183 net183 VGND VGND VPWR VPWR pcpi_rs1[20] sky130_fd_sc_hd__buf_2
Xoutput172 net172 VGND VGND VPWR VPWR pcpi_rs1[10] sky130_fd_sc_hd__buf_2
XFILLER_153_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_101_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10971_ clknet_leaf_130_clk _01027_ VGND VGND VPWR VPWR decoded_imm\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_139_2549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11454_ clknet_leaf_29_clk _01492_ VGND VGND VPWR VPWR cpuregs\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10405_ clknet_leaf_10_clk _00529_ VGND VGND VPWR VPWR cpuregs\[20\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11385_ clknet_leaf_0_clk _01423_ VGND VGND VPWR VPWR cpuregs\[7\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_10336_ clknet_leaf_3_clk _00460_ VGND VGND VPWR VPWR cpuregs\[16\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_97_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10267_ clknet_leaf_125_clk _00391_ VGND VGND VPWR VPWR cpuregs\[15\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_79_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10198_ clknet_leaf_74_clk _00322_ VGND VGND VPWR VPWR cpuregs\[9\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_47_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_37_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06360_ net649 _02792_ net640 VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__a21o_1
XFILLER_148_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05311_ _01901_ _01902_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__nand2_1
X_06291_ cpuregs\[16\]\[0\] cpuregs\[17\]\[0\] cpuregs\[18\]\[0\] cpuregs\[19\]\[0\]
+ net776 net740 VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__mux4_1
X_05242_ reg_pc\[15\] decoded_imm\[15\] VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__nand2_1
X_08030_ _03845_ _03846_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__and2_1
Xinput30 mem_rdata[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
XFILLER_128_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold803 cpuregs\[8\]\[4\] VGND VGND VPWR VPWR net1911 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05173_ net827 count_cycle\[41\] net622 _01775_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__a211o_1
Xhold825 cpuregs\[22\]\[12\] VGND VGND VPWR VPWR net1933 sky130_fd_sc_hd__dlygate4sd3_1
Xhold814 cpuregs\[7\]\[5\] VGND VGND VPWR VPWR net1922 sky130_fd_sc_hd__dlygate4sd3_1
Xhold836 cpuregs\[9\]\[7\] VGND VGND VPWR VPWR net1944 sky130_fd_sc_hd__dlygate4sd3_1
Xhold847 cpuregs\[18\]\[20\] VGND VGND VPWR VPWR net1955 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_107_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold858 cpuregs\[8\]\[19\] VGND VGND VPWR VPWR net1966 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold869 cpuregs\[30\]\[13\] VGND VGND VPWR VPWR net1977 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_390 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09981_ clknet_leaf_139_clk _00105_ VGND VGND VPWR VPWR cpuregs\[12\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_143_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08932_ _04605_ _04606_ net481 _04603_ VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__o211a_1
XFILLER_103_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08863_ net679 _04540_ VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__or2_1
XFILLER_111_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07814_ count_instr\[56\] count_instr\[55\] count_instr\[54\] _03677_ VGND VGND VPWR
+ VPWR _03682_ sky130_fd_sc_hd__and4_1
X_08794_ cpuregs\[28\]\[17\] cpuregs\[29\]\[17\] cpuregs\[30\]\[17\] cpuregs\[31\]\[17\]
+ net958 net923 VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__mux4_1
XFILLER_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07745_ count_instr\[30\] _03637_ net992 VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__o21ai_1
X_04957_ instr_fence instr_and _01578_ VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__or3_1
X_09415_ net313 net2135 net397 VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__mux2_1
XFILLER_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07676_ count_instr\[5\] _03593_ net980 VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__o21ai_1
XFILLER_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06627_ cpuregs\[28\]\[11\] cpuregs\[29\]\[11\] cpuregs\[30\]\[11\] cpuregs\[31\]\[11\]
+ net779 net743 VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_101_1947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09346_ mem_rdata_q\[25\] net616 VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__and2_1
XFILLER_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06558_ net304 _02968_ _02983_ _02984_ VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__a31o_1
X_05509_ net858 net219 VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__nand2_1
X_09277_ net1169 net846 net483 VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__mux2_1
X_06489_ net606 _02911_ _02912_ _02917_ VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__a31o_1
X_08228_ _04026_ _04029_ net557 VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_134_2468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_134_2479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08159_ _03964_ _03965_ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__and2_1
X_11170_ clknet_leaf_39_clk _01211_ VGND VGND VPWR VPWR cpuregs\[23\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_10121_ clknet_leaf_26_clk _00245_ VGND VGND VPWR VPWR cpuregs\[28\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_10052_ clknet_leaf_10_clk _00176_ VGND VGND VPWR VPWR cpuregs\[13\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10954_ clknet_leaf_91_clk _01010_ VGND VGND VPWR VPWR decoded_imm\[20\] sky130_fd_sc_hd__dfxtp_2
XFILLER_71_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10885_ clknet_leaf_47_clk _00941_ VGND VGND VPWR VPWR cpuregs\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_798 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11437_ clknet_leaf_76_clk _01475_ VGND VGND VPWR VPWR cpuregs\[8\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11368_ clknet_leaf_53_clk _01406_ VGND VGND VPWR VPWR cpuregs\[6\]\[24\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_74_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_153_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10319_ clknet_leaf_45_clk _00443_ VGND VGND VPWR VPWR cpuregs\[26\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11299_ clknet_leaf_40_clk _01340_ VGND VGND VPWR VPWR cpuregs\[4\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_05860_ _02069_ _02073_ _02400_ _02070_ VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__a211o_1
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05791_ _02247_ _02352_ _02353_ _02355_ VGND VGND VPWR VPWR alu_out\[15\] sky130_fd_sc_hd__a31o_1
XFILLER_82_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07530_ net535 net1949 net425 VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__mux2_1
XFILLER_35_754 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_85_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07461_ _02580_ _03559_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__nor2_4
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07392_ net240 net2023 net445 VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__mux2_1
X_09200_ net814 _01125_ net332 VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__mux2_1
XFILLER_50_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06412_ cpuregs\[20\]\[4\] cpuregs\[21\]\[4\] cpuregs\[22\]\[4\] cpuregs\[23\]\[4\]
+ net785 net749 VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__mux4_1
XFILLER_147_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09131_ is_alu_reg_imm net556 VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__nand2_1
X_06343_ _01626_ _02775_ _02776_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__o21a_1
XFILLER_148_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_148_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09062_ _02241_ net810 VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__nand2b_1
XTAP_TAPCELL_ROW_20_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06274_ cpuregs\[4\]\[0\] cpuregs\[5\]\[0\] cpuregs\[6\]\[0\] cpuregs\[7\]\[0\] net782
+ net746 VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__mux4_1
XFILLER_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_116_2187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05225_ count_instr\[45\] net818 net819 count_instr\[13\] VGND VGND VPWR VPWR _01824_
+ sky130_fd_sc_hd__a22o_1
X_08013_ _03706_ _03707_ _03802_ VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__and3_1
Xhold600 cpuregs\[18\]\[12\] VGND VGND VPWR VPWR net1708 sky130_fd_sc_hd__dlygate4sd3_1
Xhold611 cpuregs\[27\]\[7\] VGND VGND VPWR VPWR net1719 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold622 cpuregs\[8\]\[23\] VGND VGND VPWR VPWR net1730 sky130_fd_sc_hd__dlygate4sd3_1
X_05156_ _01546_ _01749_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__nor2_2
Xhold633 cpuregs\[24\]\[10\] VGND VGND VPWR VPWR net1741 sky130_fd_sc_hd__dlygate4sd3_1
Xhold644 cpuregs\[6\]\[8\] VGND VGND VPWR VPWR net1752 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold688 cpuregs\[20\]\[13\] VGND VGND VPWR VPWR net1796 sky130_fd_sc_hd__dlygate4sd3_1
Xhold655 cpuregs\[23\]\[2\] VGND VGND VPWR VPWR net1763 sky130_fd_sc_hd__dlygate4sd3_1
Xhold677 cpuregs\[27\]\[6\] VGND VGND VPWR VPWR net1785 sky130_fd_sc_hd__dlygate4sd3_1
Xhold666 cpuregs\[9\]\[1\] VGND VGND VPWR VPWR net1774 sky130_fd_sc_hd__dlygate4sd3_1
Xhold699 cpuregs\[17\]\[27\] VGND VGND VPWR VPWR net1807 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_134_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09964_ clknet_leaf_58_clk _00088_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dfxtp_1
X_05087_ net11 _01656_ net130 net26 _01695_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__a221o_1
X_08915_ net218 net632 _04589_ _04590_ VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__o22a_1
XFILLER_112_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09895_ net1112 VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__clkbuf_1
XFILLER_76_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08846_ cpuregs\[28\]\[20\] cpuregs\[29\]\[20\] cpuregs\[30\]\[20\] cpuregs\[31\]\[20\]
+ net960 net925 VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__mux4_1
XFILLER_97_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08777_ cpuregs\[8\]\[16\] cpuregs\[9\]\[16\] cpuregs\[10\]\[16\] cpuregs\[11\]\[16\]
+ net965 net930 VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__mux4_1
XFILLER_85_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05989_ reg_out\[15\] reg_next_pc\[15\] net572 VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__mux2_1
XFILLER_73_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07728_ count_instr\[24\] _03626_ VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__and2_1
XFILLER_72_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07659_ net239 net1377 net413 VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__mux2_1
X_10670_ clknet_leaf_64_clk _04895_ VGND VGND VPWR VPWR reg_out\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_53_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_136_2508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09329_ net2241 net491 _04822_ _04824_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_153_2800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11222_ clknet_leaf_0_clk _01263_ VGND VGND VPWR VPWR cpuregs\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_135_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11153_ clknet_leaf_144_clk _01194_ VGND VGND VPWR VPWR cpuregs\[23\]\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_8_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11084_ clknet_leaf_151_clk _01135_ VGND VGND VPWR VPWR cpuregs\[24\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_10104_ clknet_leaf_136_clk _00228_ VGND VGND VPWR VPWR cpuregs\[28\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_10035_ clknet_leaf_64_clk _00159_ VGND VGND VPWR VPWR cpuregs\[30\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_857 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10937_ clknet_leaf_111_clk _00993_ VGND VGND VPWR VPWR latched_rd\[1\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_67_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10868_ clknet_leaf_145_clk _00924_ VGND VGND VPWR VPWR cpuregs\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_129_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10799_ clknet_leaf_102_clk _00858_ VGND VGND VPWR VPWR instr_lhu sky130_fd_sc_hd__dfxtp_1
XFILLER_31_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05010_ net810 net713 VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__and2b_1
XFILLER_141_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout409 _04205_ VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__clkbuf_4
X_06961_ _03369_ _03370_ _03372_ _03371_ net729 net724 VGND VGND VPWR VPWR _03373_
+ sky130_fd_sc_hd__mux4_2
X_05912_ _02083_ _02455_ _02225_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__a21o_1
X_09680_ net1509 net312 net365 VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__mux2_1
X_08700_ cpuregs\[28\]\[12\] cpuregs\[29\]\[12\] cpuregs\[30\]\[12\] cpuregs\[31\]\[12\]
+ net947 net912 VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__mux4_1
XFILLER_104_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06892_ net864 net509 _03226_ net497 VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_87_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08631_ cpuregs\[12\]\[8\] cpuregs\[13\]\[8\] cpuregs\[14\]\[8\] cpuregs\[15\]\[8\]
+ net944 net909 VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__mux4_1
X_05843_ _02060_ _02065_ _02064_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__o21ai_1
XFILLER_66_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05774_ _02148_ net577 _02339_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__a21o_1
XFILLER_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08562_ _01563_ net630 _04257_ VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__o21ai_1
X_08493_ net77 net1222 net408 VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__mux2_1
X_07513_ net1493 net289 net428 VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__mux2_1
XFILLER_81_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07444_ net1350 net301 net435 VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__mux2_1
XFILLER_23_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_2227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_2216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07375_ net314 net1742 net443 VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__mux2_1
X_09114_ net721 net4 net613 VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__mux2_1
X_06326_ net727 _02753_ _02759_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__a21o_1
X_06257_ net247 net2001 net479 VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__mux2_1
XFILLER_135_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09045_ cpuregs\[16\]\[31\] cpuregs\[17\]\[31\] cpuregs\[18\]\[31\] cpuregs\[19\]\[31\]
+ net962 net927 VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__mux4_1
XFILLER_135_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_131_2427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05208_ _01806_ _01807_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__nand2_1
XFILLER_2_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_144_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06188_ reg_pc\[15\] reg_pc\[14\] _02632_ VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__and3_1
Xhold430 cpuregs\[17\]\[10\] VGND VGND VPWR VPWR net1538 sky130_fd_sc_hd__dlygate4sd3_1
Xhold463 cpuregs\[30\]\[1\] VGND VGND VPWR VPWR net1571 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold441 cpuregs\[6\]\[9\] VGND VGND VPWR VPWR net1549 sky130_fd_sc_hd__dlygate4sd3_1
Xhold452 cpuregs\[7\]\[9\] VGND VGND VPWR VPWR net1560 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold496 cpuregs\[26\]\[24\] VGND VGND VPWR VPWR net1604 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold474 cpuregs\[17\]\[2\] VGND VGND VPWR VPWR net1582 sky130_fd_sc_hd__dlygate4sd3_1
Xhold485 cpuregs\[20\]\[11\] VGND VGND VPWR VPWR net1593 sky130_fd_sc_hd__dlygate4sd3_1
X_05139_ _01742_ _01743_ _01741_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__o21a_1
XFILLER_131_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout932 net933 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_5_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout921 net922 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__clkbuf_2
Xfanout943 net945 VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__buf_4
Xfanout910 net917 VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__buf_2
X_09947_ clknet_leaf_129_clk _00071_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dfxtp_1
Xfanout965 net967 VGND VGND VPWR VPWR net965 sky130_fd_sc_hd__buf_4
Xfanout976 net990 VGND VGND VPWR VPWR net976 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_51_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout954 net957 VGND VGND VPWR VPWR net954 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_146_2670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_2389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1130 count_cycle\[63\] VGND VGND VPWR VPWR net2238 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1141 count_instr\[27\] VGND VGND VPWR VPWR net2249 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout998 net999 VGND VGND VPWR VPWR net998 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_85_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout987 net989 VGND VGND VPWR VPWR net987 sky130_fd_sc_hd__clkbuf_2
X_09878_ net1116 VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__clkbuf_1
X_08829_ cpuregs\[28\]\[19\] cpuregs\[29\]\[19\] cpuregs\[30\]\[19\] cpuregs\[31\]\[19\]
+ net961 net926 VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__mux4_1
Xhold1185 count_cycle\[21\] VGND VGND VPWR VPWR net2293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1152 count_instr\[51\] VGND VGND VPWR VPWR net2260 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_85_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1174 instr_sb VGND VGND VPWR VPWR net2282 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1163 count_cycle\[39\] VGND VGND VPWR VPWR net2271 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_18_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1196 count_cycle\[42\] VGND VGND VPWR VPWR net2304 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_146_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_146_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_53_370 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10722_ clknet_leaf_137_clk _00813_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dfxtp_2
XFILLER_110_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xpicorv32_1070 VGND VGND VPWR VPWR picorv32_1070/HI pcpi_insn[31] sky130_fd_sc_hd__conb_1
X_10653_ clknet_leaf_127_clk _04908_ VGND VGND VPWR VPWR reg_out\[5\] sky130_fd_sc_hd__dfxtp_1
Xpicorv32_1092 VGND VGND VPWR VPWR picorv32_1092/HI trace_data[20] sky130_fd_sc_hd__conb_1
Xpicorv32_1081 VGND VGND VPWR VPWR picorv32_1081/HI trace_data[9] sky130_fd_sc_hd__conb_1
X_10584_ clknet_leaf_111_clk net2339 VGND VGND VPWR VPWR count_cycle\[1\] sky130_fd_sc_hd__dfxtp_1
Xclkload19 clknet_leaf_153_clk VGND VGND VPWR VPWR clkload19/Y sky130_fd_sc_hd__inv_8
XFILLER_135_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11205_ clknet_leaf_65_clk _01246_ VGND VGND VPWR VPWR cpuregs\[29\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11136_ clknet_leaf_22_clk _01177_ VGND VGND VPWR VPWR cpuregs\[31\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_548 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11067_ clknet_leaf_130_clk _01118_ VGND VGND VPWR VPWR mem_rdata_q\[24\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_69_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10018_ clknet_leaf_15_clk _00142_ VGND VGND VPWR VPWR cpuregs\[30\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_137_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_137_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_45_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05490_ net865 net213 VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__nor2_1
XFILLER_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07160_ net1458 net535 net467 VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__mux2_1
X_07091_ cpuregs\[20\]\[28\] cpuregs\[21\]\[28\] cpuregs\[22\]\[28\] cpuregs\[23\]\[28\]
+ net805 net768 VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__mux4_1
XFILLER_118_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06111_ latched_rd\[2\] latched_rd\[4\] latched_rd\[3\] VGND VGND VPWR VPWR _02578_
+ sky130_fd_sc_hd__or3b_1
X_06042_ decoded_imm_j\[18\] _01112_ net333 VGND VGND VPWR VPWR _00035_ sky130_fd_sc_hd__mux2_1
XFILLER_117_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_2146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09801_ net532 net2149 net350 VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__mux2_1
Xfanout239 net242 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_2
X_07993_ _03812_ _03813_ net976 VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__o21a_1
X_09732_ _03565_ _04873_ VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__or2_4
X_06944_ _03354_ _03355_ VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__nor2_1
XFILLER_28_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09663_ net242 net1675 net371 VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__mux2_1
X_06875_ cpuregs\[16\]\[20\] cpuregs\[17\]\[20\] cpuregs\[18\]\[20\] cpuregs\[19\]\[20\]
+ net792 net755 VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__mux4_1
XFILLER_54_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09594_ net1612 net251 net379 VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__mux2_1
X_05826_ _02069_ _02073_ _02385_ _02070_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__a31o_1
XFILLER_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08614_ cpuregs\[8\]\[7\] cpuregs\[9\]\[7\] cpuregs\[10\]\[7\] cpuregs\[11\]\[7\]
+ net944 net909 VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__mux4_1
XFILLER_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_808 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08545_ net896 _04238_ _04242_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__a21oi_1
X_05757_ _02294_ _02321_ _02324_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__o21ai_1
XFILLER_51_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_128_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_128_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_35_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05688_ _02129_ _02185_ _02183_ net692 VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__a211o_1
X_08476_ net90 net1181 net406 VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__mux2_1
XFILLER_23_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07427_ latched_rd\[2\] latched_rd\[3\] latched_rd\[4\] _02579_ VGND VGND VPWR VPWR
+ _03575_ sky130_fd_sc_hd__and4b_1
XFILLER_148_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07358_ net1610 net243 net448 VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__mux2_1
XFILLER_6_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06309_ net705 _01626_ VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__nand2_1
X_07289_ net1803 net253 net457 VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__mux2_1
X_09028_ cpuregs\[8\]\[30\] cpuregs\[9\]\[30\] cpuregs\[10\]\[30\] cpuregs\[11\]\[30\]
+ net974 net939 VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__mux4_1
Xhold271 cpuregs\[26\]\[16\] VGND VGND VPWR VPWR net1379 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold260 cpuregs\[13\]\[1\] VGND VGND VPWR VPWR net1368 sky130_fd_sc_hd__dlygate4sd3_1
Xhold293 cpuregs\[13\]\[28\] VGND VGND VPWR VPWR net1401 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_120_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold282 cpuregs\[21\]\[0\] VGND VGND VPWR VPWR net1390 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_49_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout751 net772 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__clkbuf_2
Xfanout740 net741 VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_144_2629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout762 net764 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__clkbuf_4
Xfanout784 net809 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__buf_2
XFILLER_49_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout773 net774 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__buf_4
Xfanout795 net796 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__buf_4
XFILLER_58_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_100 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_46_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_111 net735 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_119_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_119_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_42_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10705_ clknet_leaf_82_clk _00797_ VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfxtp_1
X_10636_ clknet_leaf_83_clk _00760_ VGND VGND VPWR VPWR count_cycle\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_139_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload119 clknet_leaf_61_clk VGND VGND VPWR VPWR clkload119/Y sky130_fd_sc_hd__inv_6
Xclkload108 clknet_leaf_100_clk VGND VGND VPWR VPWR clkload108/Y sky130_fd_sc_hd__clkinv_2
X_10567_ clknet_leaf_94_clk _00691_ VGND VGND VPWR VPWR reg_next_pc\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10498_ clknet_leaf_106_clk _00622_ VGND VGND VPWR VPWR count_instr\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04990_ mem_do_prefetch _01601_ net608 _01614_ VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__a31o_1
X_11119_ clknet_leaf_116_clk _01160_ VGND VGND VPWR VPWR cpuregs\[31\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_77_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput6 mem_rdata[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_37_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06660_ _03079_ _03080_ net646 VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__mux2_1
X_05611_ _01558_ net845 _02190_ VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__o21ai_1
XFILLER_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06591_ _03013_ _03014_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__or2_1
XFILLER_18_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08330_ net2355 _04100_ _04102_ VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__o21a_1
X_05542_ net875 net204 VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__and2_1
X_05473_ net859 net218 VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__or2_1
X_08261_ reg_next_pc\[31\] net690 net547 _03728_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_15_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07212_ net1838 net293 net463 VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__mux2_1
XFILLER_20_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08192_ _03994_ _03996_ net557 VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__a21oi_1
XFILLER_134_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07143_ cpuregs\[4\]\[30\] cpuregs\[5\]\[30\] cpuregs\[6\]\[30\] cpuregs\[7\]\[30\]
+ net807 net770 VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__mux4_1
XFILLER_133_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07074_ _03406_ _03431_ _03454_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_95_1849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06025_ mem_rdata_q\[20\] net13 net611 VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__mux2_1
XFILLER_102_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_142_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07976_ _03791_ _03792_ _03795_ _03797_ VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__o22ai_1
X_06927_ cpuregs\[28\]\[22\] cpuregs\[29\]\[22\] cpuregs\[30\]\[22\] cpuregs\[31\]\[22\]
+ net797 net760 VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_126_2348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09715_ net299 net1656 net361 VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__mux2_1
X_09646_ net312 net1687 net369 VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__mux2_1
X_06858_ decoded_imm\[20\] net864 VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__nor2_1
XFILLER_83_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05809_ _02048_ _02110_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__nor2_1
X_06789_ cpuregs\[12\]\[17\] cpuregs\[13\]\[17\] cpuregs\[14\]\[17\] cpuregs\[15\]\[17\]
+ net793 net757 VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__mux4_1
X_09577_ net1590 _02620_ net377 VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__mux2_1
XFILLER_43_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08528_ _04225_ _04226_ net671 VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__mux2_1
XFILLER_42_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_104_1989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08459_ cpuregs\[20\]\[31\] cpuregs\[21\]\[31\] net794 VGND VGND VPWR VPWR _04193_
+ sky130_fd_sc_hd__mux2_1
XFILLER_51_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11470_ clknet_leaf_79_clk _01508_ VGND VGND VPWR VPWR cpuregs\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_10421_ clknet_leaf_75_clk _00545_ VGND VGND VPWR VPWR cpuregs\[20\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10352_ clknet_leaf_52_clk _00476_ VGND VGND VPWR VPWR cpuregs\[16\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10283_ clknet_leaf_26_clk _00407_ VGND VGND VPWR VPWR cpuregs\[15\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_120_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout592 _01661_ VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout581 _02243_ VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__clkbuf_4
Xfanout570 net571 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__clkbuf_4
XFILLER_101_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10619_ clknet_leaf_109_clk _00743_ VGND VGND VPWR VPWR count_cycle\[36\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_77_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_77_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_90_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07830_ count_instr\[62\] count_instr\[61\] count_instr\[60\] _03687_ VGND VGND VPWR
+ VPWR _03692_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_90_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07761_ count_instr\[36\] _03647_ net981 VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__o21ai_1
XFILLER_110_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_2067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_2056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06712_ _03127_ _03128_ net651 VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__mux2_1
X_04973_ net33 net134 VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__and2_1
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09500_ _02580_ _03563_ VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__nor2_2
XFILLER_37_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07692_ count_instr\[11\] _03603_ net987 VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__o21ai_1
X_09431_ net243 net1899 net399 VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__mux2_1
XFILLER_80_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06643_ _03012_ _03041_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__nand2b_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_121_2267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09362_ net838 decoded_imm_j\[17\] _01577_ mem_rdata_q\[17\] VGND VGND VPWR VPWR
+ _04843_ sky130_fd_sc_hd__a22o_1
X_06574_ cpuregs\[0\]\[9\] cpuregs\[1\]\[9\] cpuregs\[2\]\[9\] cpuregs\[3\]\[9\] net774
+ net738 VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__mux4_1
XFILLER_24_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05525_ net856 net221 VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__and2_1
X_08313_ count_cycle\[19\] _04090_ net994 VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__o21ai_1
XFILLER_33_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_22 _03322_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09293_ net1167 net106 net485 VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__mux2_1
XANTENNA_11 _02242_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_55 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_33 _04868_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08244_ _04033_ _04036_ _04034_ VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__a21o_1
X_05456_ _02024_ _02027_ _02036_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__a21o_1
XANTENNA_44 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_66 net366 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_88 net802 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_99 net905 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08175_ _03972_ _03721_ VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__and2b_1
X_05387_ net715 _01966_ _01967_ _01973_ VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__a31o_1
XANTENNA_77 net629 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07126_ net525 _03515_ _03516_ _03517_ _03531_ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__o41a_1
XFILLER_134_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07057_ net736 _03464_ VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__or2_1
Xoutput151 net151 VGND VGND VPWR VPWR mem_wdata[24] sky130_fd_sc_hd__buf_2
Xoutput140 net140 VGND VGND VPWR VPWR mem_wdata[14] sky130_fd_sc_hd__buf_2
Xoutput184 net863 VGND VGND VPWR VPWR pcpi_rs1[21] sky130_fd_sc_hd__buf_2
X_06008_ net187 _02506_ net637 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__mux2_1
Xoutput195 net195 VGND VGND VPWR VPWR pcpi_rs1[31] sky130_fd_sc_hd__buf_2
Xoutput173 net173 VGND VGND VPWR VPWR pcpi_rs1[11] sky130_fd_sc_hd__buf_2
Xoutput162 net162 VGND VGND VPWR VPWR mem_wdata[5] sky130_fd_sc_hd__buf_2
XFILLER_102_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07959_ _03757_ _03760_ _03769_ _03768_ VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__o31a_1
XTAP_TAPCELL_ROW_48_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10970_ clknet_leaf_130_clk _01026_ VGND VGND VPWR VPWR decoded_imm\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09629_ net246 net1357 net376 VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__mux2_1
XFILLER_43_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_50_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_50_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_8_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11453_ clknet_leaf_7_clk _01491_ VGND VGND VPWR VPWR cpuregs\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10404_ clknet_leaf_7_clk _00528_ VGND VGND VPWR VPWR cpuregs\[20\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_137_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11384_ clknet_leaf_2_clk _01422_ VGND VGND VPWR VPWR cpuregs\[7\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10335_ clknet_leaf_152_clk _00459_ VGND VGND VPWR VPWR cpuregs\[16\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10266_ clknet_leaf_115_clk _00390_ VGND VGND VPWR VPWR cpuregs\[15\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_72_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10197_ clknet_leaf_72_clk _00321_ VGND VGND VPWR VPWR cpuregs\[9\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_590 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_906 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_41_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_41_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_148_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05310_ reg_pc\[20\] decoded_imm\[20\] VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__nand2_1
X_06290_ _02723_ _02724_ net644 VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__mux2_1
XFILLER_147_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05241_ reg_pc\[15\] decoded_imm\[15\] VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__nor2_1
Xinput31 mem_rdata[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput20 mem_rdata[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_2
X_05172_ count_instr\[41\] net818 net819 count_instr\[9\] VGND VGND VPWR VPWR _01775_
+ sky130_fd_sc_hd__a22o_1
Xhold837 cpuregs\[16\]\[22\] VGND VGND VPWR VPWR net1945 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold815 cpuregs\[20\]\[14\] VGND VGND VPWR VPWR net1923 sky130_fd_sc_hd__dlygate4sd3_1
Xhold804 cpuregs\[10\]\[13\] VGND VGND VPWR VPWR net1912 sky130_fd_sc_hd__dlygate4sd3_1
Xhold826 cpuregs\[13\]\[2\] VGND VGND VPWR VPWR net1934 sky130_fd_sc_hd__dlygate4sd3_1
Xhold859 cpuregs\[7\]\[10\] VGND VGND VPWR VPWR net1967 sky130_fd_sc_hd__dlygate4sd3_1
X_09980_ clknet_leaf_144_clk _00104_ VGND VGND VPWR VPWR cpuregs\[12\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xhold848 cpuregs\[6\]\[4\] VGND VGND VPWR VPWR net1956 sky130_fd_sc_hd__dlygate4sd3_1
X_08931_ _00011_ _04604_ net667 VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__a21o_1
XFILLER_103_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08862_ cpuregs\[20\]\[21\] cpuregs\[21\]\[21\] cpuregs\[22\]\[21\] cpuregs\[23\]\[21\]
+ net963 net928 VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__mux4_1
X_07813_ _03681_ net998 _03680_ VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__and3b_1
XFILLER_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08793_ cpuregs\[8\]\[17\] cpuregs\[9\]\[17\] cpuregs\[10\]\[17\] cpuregs\[11\]\[17\]
+ net958 net923 VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_123_2307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07744_ _03637_ _03638_ VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__nor2_1
X_04956_ instr_lh instr_jalr net835 _01582_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__or4_1
XFILLER_53_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07675_ _03593_ _03594_ VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__nor2_1
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09414_ net316 net1708 net397 VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__mux2_1
XFILLER_25_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06626_ cpuregs\[8\]\[11\] cpuregs\[9\]\[11\] cpuregs\[10\]\[11\] cpuregs\[11\]\[11\]
+ net778 net742 VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__mux4_1
XFILLER_80_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_32_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_32_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_101_1948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09345_ net2369 net553 net401 _04834_ VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__o22a_1
X_06557_ net877 net303 VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__and2_1
XFILLER_40_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05508_ _02082_ _02087_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__nor2_1
X_09276_ net1185 net108 net483 VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__mux2_1
X_06488_ net523 _02914_ _02916_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__or3_1
X_08227_ net838 _04027_ _04028_ VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__or3_1
X_05439_ net703 net343 _02018_ net708 net853 VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_151_2750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_2469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08158_ net812 _03720_ VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__or2_1
X_07109_ _03512_ _03513_ _03514_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__o21a_1
X_08089_ _03897_ _03899_ _03901_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__and3b_1
X_10120_ clknet_leaf_53_clk _00244_ VGND VGND VPWR VPWR cpuregs\[28\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_99_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_99_clk sky130_fd_sc_hd__clkbuf_8
X_10051_ clknet_leaf_3_clk _00175_ VGND VGND VPWR VPWR cpuregs\[13\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_54_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10953_ clknet_leaf_91_clk _01009_ VGND VGND VPWR VPWR decoded_imm\[21\] sky130_fd_sc_hd__dfxtp_2
XFILLER_84_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_3_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10884_ clknet_leaf_40_clk _00940_ VGND VGND VPWR VPWR cpuregs\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_23_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_12_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11436_ clknet_leaf_71_clk _01474_ VGND VGND VPWR VPWR cpuregs\[8\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_138_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_874 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11367_ clknet_leaf_46_clk _01405_ VGND VGND VPWR VPWR cpuregs\[6\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_74_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10318_ clknet_leaf_42_clk _00442_ VGND VGND VPWR VPWR cpuregs\[26\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11298_ clknet_leaf_36_clk _01339_ VGND VGND VPWR VPWR cpuregs\[4\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10249_ clknet_leaf_27_clk _00373_ VGND VGND VPWR VPWR cpuregs\[27\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_105_2015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05790_ _02150_ net580 net576 _02152_ _02354_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__a221o_1
XFILLER_35_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07460_ net1913 net238 net436 VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_85_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07391_ net245 net1802 net445 VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__mux2_1
X_06411_ cpuregs\[16\]\[4\] cpuregs\[17\]\[4\] cpuregs\[18\]\[4\] cpuregs\[19\]\[4\]
+ net785 net749 VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__mux4_1
X_09130_ net2340 net549 _04761_ is_sb_sh_sw VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__a22o_1
X_06342_ net705 net880 net508 net496 VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__a31o_1
Xclkbuf_leaf_14_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_09061_ net227 net632 _04727_ _04728_ VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__o22a_1
XFILLER_30_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_147_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06273_ net237 net2236 net478 VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__mux2_1
X_08012_ _03706_ _03802_ _03707_ VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_7_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold612 cpuregs\[11\]\[26\] VGND VGND VPWR VPWR net1720 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05224_ _01760_ _01822_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__or2_1
Xhold601 cpuregs\[24\]\[11\] VGND VGND VPWR VPWR net1709 sky130_fd_sc_hd__dlygate4sd3_1
Xhold623 cpuregs\[2\]\[20\] VGND VGND VPWR VPWR net1731 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_116_2188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold634 cpuregs\[9\]\[13\] VGND VGND VPWR VPWR net1742 sky130_fd_sc_hd__dlygate4sd3_1
X_05155_ _01742_ net334 _01757_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__o21ai_1
Xhold645 cpuregs\[9\]\[4\] VGND VGND VPWR VPWR net1753 sky130_fd_sc_hd__dlygate4sd3_1
Xhold656 cpuregs\[13\]\[31\] VGND VGND VPWR VPWR net1764 sky130_fd_sc_hd__dlygate4sd3_1
Xhold678 cpuregs\[23\]\[19\] VGND VGND VPWR VPWR net1786 sky130_fd_sc_hd__dlygate4sd3_1
X_09963_ clknet_leaf_58_clk _00087_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dfxtp_2
X_05086_ net887 net698 _01694_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__and3_1
Xhold667 cpuregs\[4\]\[10\] VGND VGND VPWR VPWR net1775 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08914_ decoded_imm\[23\] net598 net627 VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__a21o_1
XFILLER_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold689 cpuregs\[7\]\[3\] VGND VGND VPWR VPWR net1797 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_134_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09894_ net1126 VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__clkbuf_1
XFILLER_112_782 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08845_ net902 _04523_ VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__or2_1
XFILLER_111_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08776_ cpuregs\[24\]\[16\] cpuregs\[25\]\[16\] cpuregs\[26\]\[16\] cpuregs\[27\]\[16\]
+ net965 net930 VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__mux4_1
XFILLER_45_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07727_ _03626_ _03627_ VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__nor2_1
X_05988_ net872 _02496_ net636 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__mux2_2
XFILLER_57_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04939_ net722 VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_0_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07658_ net245 net1715 net413 VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__mux2_1
XFILLER_81_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07589_ net1791 net251 net421 VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__mux2_1
X_06609_ net647 _03024_ _03026_ net726 VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__o211a_1
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_25_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_136_2509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09328_ net811 decoded_imm_j\[1\] _04823_ net707 VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_153_2801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_126_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09259_ _04741_ _04742_ _04797_ _02515_ net2167 VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__a32o_1
XFILLER_153_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11221_ clknet_leaf_3_clk _01262_ VGND VGND VPWR VPWR cpuregs\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_150_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11152_ clknet_leaf_123_clk _01193_ VGND VGND VPWR VPWR cpuregs\[23\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10103_ clknet_leaf_24_clk _00227_ VGND VGND VPWR VPWR cpuregs\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_8_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11083_ clknet_leaf_150_clk _01134_ VGND VGND VPWR VPWR cpuregs\[24\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_10034_ clknet_leaf_50_clk _00158_ VGND VGND VPWR VPWR cpuregs\[30\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_27_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10936_ clknet_leaf_111_clk _00992_ VGND VGND VPWR VPWR latched_rd\[0\] sky130_fd_sc_hd__dfxtp_4
XFILLER_44_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10867_ clknet_leaf_143_clk _00923_ VGND VGND VPWR VPWR cpuregs\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_31_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10798_ clknet_leaf_98_clk _00857_ VGND VGND VPWR VPWR instr_lbu sky130_fd_sc_hd__dfxtp_1
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_129_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11419_ clknet_leaf_4_clk _01457_ VGND VGND VPWR VPWR cpuregs\[8\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_141_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_87_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_141_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06960_ _03367_ _03368_ net654 VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__mux2_1
XFILLER_101_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_3_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
X_05911_ _02080_ _02454_ _02081_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__a21o_1
X_06891_ net607 _03301_ _03304_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__and3_1
XFILLER_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05842_ _02062_ _02066_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_87_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08630_ cpuregs\[0\]\[8\] cpuregs\[1\]\[8\] cpuregs\[2\]\[8\] cpuregs\[3\]\[8\] net941
+ net906 VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__mux4_1
XFILLER_39_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_828 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05773_ _02147_ net585 net579 _02146_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__a22o_1
XFILLER_54_338 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08561_ net601 _02556_ _04256_ net629 VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__a211o_1
XFILLER_120_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08492_ net76 net1172 net409 VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__mux2_1
X_07512_ net1773 net293 net428 VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__mux2_1
XFILLER_62_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07443_ net1474 net310 net435 VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__mux2_1
XFILLER_23_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_2217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09113_ net720 net5 net613 VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__mux2_1
X_07374_ net318 net2198 net442 VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__mux2_1
XFILLER_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06325_ net641 _02758_ net723 VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__a21o_1
X_06256_ _02693_ _02694_ net568 VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__mux2_1
X_09044_ net678 _04711_ VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__or2_1
Xhold420 cpuregs\[31\]\[22\] VGND VGND VPWR VPWR net1528 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_131_2428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05207_ reg_pc\[12\] decoded_imm\[12\] VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__nand2_1
XFILLER_145_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold431 cpuregs\[14\]\[23\] VGND VGND VPWR VPWR net1539 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06187_ reg_pc\[14\] _02632_ reg_pc\[15\] VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__a21oi_1
Xhold442 cpuregs\[30\]\[15\] VGND VGND VPWR VPWR net1550 sky130_fd_sc_hd__dlygate4sd3_1
Xhold453 cpuregs\[3\]\[9\] VGND VGND VPWR VPWR net1561 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout900 net901 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__buf_4
Xhold486 cpuregs\[3\]\[3\] VGND VGND VPWR VPWR net1594 sky130_fd_sc_hd__dlygate4sd3_1
Xhold464 cpuregs\[2\]\[8\] VGND VGND VPWR VPWR net1572 sky130_fd_sc_hd__dlygate4sd3_1
Xhold475 cpuregs\[22\]\[8\] VGND VGND VPWR VPWR net1583 sky130_fd_sc_hd__dlygate4sd3_1
X_05138_ reg_pc\[7\] decoded_imm\[7\] VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__nor2_1
Xfanout933 net940 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__clkbuf_4
Xfanout911 net914 VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_5_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold497 cpuregs\[20\]\[5\] VGND VGND VPWR VPWR net1605 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout922 _00008_ VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__clkbuf_2
X_09946_ clknet_leaf_129_clk _00070_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dfxtp_2
X_05069_ reg_pc\[2\] decoded_imm\[2\] VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__nand2_1
Xfanout966 net967 VGND VGND VPWR VPWR net966 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_51_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout955 net957 VGND VGND VPWR VPWR net955 sky130_fd_sc_hd__buf_4
Xfanout977 net990 VGND VGND VPWR VPWR net977 sky130_fd_sc_hd__clkbuf_4
Xfanout944 net945 VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_146_2671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1120 cpuregs\[22\]\[16\] VGND VGND VPWR VPWR net2228 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1142 count_cycle\[19\] VGND VGND VPWR VPWR net2250 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout999 net1002 VGND VGND VPWR VPWR net999 sky130_fd_sc_hd__clkbuf_2
Xfanout988 net989 VGND VGND VPWR VPWR net988 sky130_fd_sc_hd__clkbuf_2
Xhold1131 is_sll_srl_sra VGND VGND VPWR VPWR net2239 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_51_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09877_ net1121 VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__clkbuf_1
X_08828_ cpuregs\[8\]\[19\] cpuregs\[9\]\[19\] cpuregs\[10\]\[19\] cpuregs\[11\]\[19\]
+ net961 net926 VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__mux4_1
XFILLER_85_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1153 count_cycle\[48\] VGND VGND VPWR VPWR net2261 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1175 instr_andi VGND VGND VPWR VPWR net2283 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_57_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1164 count_instr\[5\] VGND VGND VPWR VPWR net2272 sky130_fd_sc_hd__dlygate4sd3_1
X_08759_ cpuregs\[8\]\[15\] cpuregs\[9\]\[15\] cpuregs\[10\]\[15\] cpuregs\[11\]\[15\]
+ net961 net926 VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__mux4_1
Xhold1186 count_instr\[39\] VGND VGND VPWR VPWR net2294 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1197 count_instr\[4\] VGND VGND VPWR VPWR net2305 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_26_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10721_ clknet_leaf_141_clk _00812_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dfxtp_4
XFILLER_41_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xpicorv32_1060 VGND VGND VPWR VPWR picorv32_1060/HI pcpi_insn[21] sky130_fd_sc_hd__conb_1
X_10652_ clknet_leaf_126_clk _04907_ VGND VGND VPWR VPWR reg_out\[4\] sky130_fd_sc_hd__dfxtp_1
Xpicorv32_1093 VGND VGND VPWR VPWR picorv32_1093/HI trace_data[21] sky130_fd_sc_hd__conb_1
Xpicorv32_1082 VGND VGND VPWR VPWR picorv32_1082/HI trace_data[10] sky130_fd_sc_hd__conb_1
Xpicorv32_1071 VGND VGND VPWR VPWR picorv32_1071/HI pcpi_valid sky130_fd_sc_hd__conb_1
X_10583_ clknet_leaf_112_clk _00707_ VGND VGND VPWR VPWR count_cycle\[0\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11204_ clknet_leaf_45_clk _01245_ VGND VGND VPWR VPWR cpuregs\[29\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_170 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_123_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11135_ clknet_leaf_24_clk _01176_ VGND VGND VPWR VPWR cpuregs\[31\]\[18\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_79_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11066_ clknet_leaf_111_clk _01117_ VGND VGND VPWR VPWR mem_rdata_q\[23\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10017_ clknet_leaf_151_clk _00141_ VGND VGND VPWR VPWR cpuregs\[30\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_69_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_88_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_82_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10919_ clknet_leaf_30_clk _00975_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dfxtp_1
XFILLER_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07090_ cpuregs\[0\]\[28\] cpuregs\[1\]\[28\] cpuregs\[2\]\[28\] cpuregs\[3\]\[28\]
+ net805 net768 VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__mux4_1
X_06110_ _02576_ _02577_ _02559_ VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__a21oi_1
XFILLER_145_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06041_ mem_rdata_q\[18\] net10 net613 VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__mux2_1
XFILLER_114_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_2147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_2136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_97_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07992_ net688 reg_next_pc\[9\] net545 _03705_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__a22o_1
X_09800_ net534 net1625 net350 VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__mux2_1
XFILLER_101_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06943_ _03325_ _03329_ _03353_ net610 VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__a31o_1
X_09731_ net237 net2113 net363 VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__mux2_1
XFILLER_67_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09662_ net243 net1993 net371 VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__mux2_1
X_06874_ cpuregs\[20\]\[20\] cpuregs\[21\]\[20\] cpuregs\[22\]\[20\] cpuregs\[23\]\[20\]
+ net797 net760 VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__mux4_1
X_09593_ net1440 net256 net379 VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__mux2_1
XFILLER_131_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05825_ _02076_ _02372_ VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__or2_1
XFILLER_54_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08613_ net670 _04304_ VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__or2_1
X_05756_ _02118_ _02122_ _02323_ _02119_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__o31ai_1
XFILLER_54_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08544_ net668 _04241_ net891 VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__a21o_1
XFILLER_36_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_141_2590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05687_ _02127_ _02257_ _02126_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__o21a_1
X_08475_ net89 net1159 net406 VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__mux2_1
XFILLER_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07426_ net1638 net236 net440 VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__mux2_1
XFILLER_51_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07357_ net1801 net249 net448 VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__mux2_1
XFILLER_10_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06308_ _01554_ _01625_ VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__nor2_1
X_07288_ net1574 net257 net456 VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__mux2_1
X_09027_ cpuregs\[12\]\[30\] cpuregs\[13\]\[30\] cpuregs\[14\]\[30\] cpuregs\[15\]\[30\]
+ net974 net939 VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__mux4_1
XFILLER_108_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06239_ reg_pc\[25\] _02677_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__nor2_1
Xhold261 cpuregs\[24\]\[29\] VGND VGND VPWR VPWR net1369 sky130_fd_sc_hd__dlygate4sd3_1
Xhold250 cpuregs\[15\]\[24\] VGND VGND VPWR VPWR net1358 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_148_2700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold294 cpuregs\[25\]\[23\] VGND VGND VPWR VPWR net1402 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold272 cpuregs\[13\]\[13\] VGND VGND VPWR VPWR net1380 sky130_fd_sc_hd__dlygate4sd3_1
Xhold283 cpuregs\[13\]\[6\] VGND VGND VPWR VPWR net1391 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout730 _00015_ VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__buf_4
XFILLER_120_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout741 net748 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__buf_2
Xfanout763 net764 VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09929_ clknet_leaf_36_clk _00058_ VGND VGND VPWR VPWR cpuregs\[11\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout785 net787 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__clkbuf_4
Xfanout752 net753 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__clkbuf_4
Xfanout774 net784 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__buf_4
XFILLER_100_571 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout796 net802 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__buf_2
XFILLER_86_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_101 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_112 net830 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_65_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_121_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10704_ clknet_leaf_71_clk _00796_ VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfxtp_1
XFILLER_81_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10635_ clknet_leaf_83_clk _00759_ VGND VGND VPWR VPWR count_cycle\[52\] sky130_fd_sc_hd__dfxtp_1
XFILLER_139_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkload109 clknet_leaf_101_clk VGND VGND VPWR VPWR clkload109/Y sky130_fd_sc_hd__bufinv_16
X_10566_ clknet_leaf_59_clk _00690_ VGND VGND VPWR VPWR reg_next_pc\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10497_ clknet_leaf_107_clk _00621_ VGND VGND VPWR VPWR count_instr\[40\] sky130_fd_sc_hd__dfxtp_1
X_11118_ clknet_leaf_114_clk _01159_ VGND VGND VPWR VPWR cpuregs\[31\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xinput7 mem_rdata[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__dlymetal6s2s_1
X_11049_ clknet_leaf_103_clk _01100_ VGND VGND VPWR VPWR mem_rdata_q\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_37_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05610_ _01558_ net845 _02189_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__a21o_1
XFILLER_18_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06590_ _03013_ _03014_ VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__nand2_1
XFILLER_51_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05541_ _02117_ _02119_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__nand2_1
XFILLER_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05472_ net859 net218 VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__nor2_1
X_08260_ _04054_ _04055_ _04058_ net838 VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__a22o_1
XFILLER_33_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07211_ net1951 net296 net463 VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__mux2_1
X_08191_ _03722_ _03981_ _03995_ VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_99_1920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07142_ cpuregs\[24\]\[30\] cpuregs\[25\]\[30\] cpuregs\[26\]\[30\] cpuregs\[27\]\[30\]
+ net807 net770 VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__mux4_1
XFILLER_9_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07073_ _01560_ net307 VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__nor2_1
X_06024_ _01548_ _01603_ VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__or2_4
XFILLER_113_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07975_ net832 _03796_ VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__nand2_1
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06926_ cpuregs\[24\]\[22\] cpuregs\[25\]\[22\] cpuregs\[26\]\[22\] cpuregs\[27\]\[22\]
+ net802 net765 VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_126_2349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09714_ net308 net2108 net363 VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__mux2_1
X_06857_ _03219_ _03245_ _03270_ _03271_ VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__a211o_1
X_09645_ net317 net1933 net369 VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__mux2_1
XFILLER_27_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05808_ _02050_ _02114_ _02357_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__or3b_1
XFILLER_82_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06788_ cpuregs\[16\]\[17\] cpuregs\[17\]\[17\] cpuregs\[18\]\[17\] cpuregs\[19\]\[17\]
+ net791 net754 VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__mux4_1
XFILLER_15_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09576_ net1631 net329 net377 VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__mux2_1
X_05739_ _02194_ _02308_ net692 VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__mux2_1
X_08527_ cpuregs\[16\]\[0\] cpuregs\[17\]\[0\] cpuregs\[18\]\[0\] cpuregs\[19\]\[0\]
+ net944 net909 VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__mux4_1
X_08458_ _04187_ _04191_ net728 VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_46_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07409_ net1529 net310 net438 VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10420_ clknet_leaf_72_clk _00544_ VGND VGND VPWR VPWR cpuregs\[20\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_08389_ _04139_ net996 _04138_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__and3b_1
XFILLER_51_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10351_ clknet_leaf_45_clk _00475_ VGND VGND VPWR VPWR cpuregs\[16\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_10282_ clknet_leaf_34_clk _00406_ VGND VGND VPWR VPWR cpuregs\[15\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_151_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout560 net563 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__clkbuf_4
Xfanout582 _02243_ VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__buf_2
XFILLER_76_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout593 _01659_ VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__buf_4
XFILLER_59_761 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_901 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout571 _02483_ VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__clkbuf_4
XFILLER_46_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10618_ clknet_leaf_109_clk _00742_ VGND VGND VPWR VPWR count_cycle\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_143_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10549_ clknet_leaf_80_clk _00673_ VGND VGND VPWR VPWR reg_pc\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_77_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_04972_ mem_state\[0\] mem_state\[1\] VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__and2_1
X_07760_ _03647_ _03648_ VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_108_2057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06711_ _03123_ _03124_ net735 VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__mux2_1
XFILLER_49_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09430_ net249 net1915 net399 VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__mux2_1
X_07691_ _03603_ _03604_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__nor2_1
XFILLER_25_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06642_ _03063_ _03064_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_121_2268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09361_ decoded_imm\[18\] net554 _04827_ _04842_ VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__o22a_1
XFILLER_52_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06573_ cpuregs\[4\]\[9\] cpuregs\[5\]\[9\] cpuregs\[6\]\[9\] cpuregs\[7\]\[9\] net773
+ net737 VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__mux4_1
X_05524_ _02102_ _02103_ VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__nand2_1
X_08312_ net1971 _04089_ _04091_ VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__o21a_1
X_09292_ net1163 net105 net485 VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__mux2_1
X_08243_ net1001 _04043_ VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__and2_1
XANTENNA_12 _02477_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_23 _03562_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_56 net185 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_34 _04876_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05455_ reg_pc\[31\] decoded_imm\[31\] VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__xnor2_1
XANTENNA_45 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08174_ _03978_ _03979_ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__or2_1
X_05386_ net704 net344 _01968_ _01972_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__a31o_1
XANTENNA_89 net831 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_78 net640 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_67 net419 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07125_ reg_pc\[29\] net562 _03530_ net519 net522 VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__a221o_1
XFILLER_106_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07056_ cpuregs\[24\]\[27\] cpuregs\[25\]\[27\] cpuregs\[26\]\[27\] cpuregs\[27\]\[27\]
+ net804 net767 VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__mux4_1
XFILLER_106_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06007_ reg_out\[24\] reg_next_pc\[24\] net573 VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__mux2_1
Xoutput141 net141 VGND VGND VPWR VPWR mem_wdata[15] sky130_fd_sc_hd__buf_2
Xoutput152 net152 VGND VGND VPWR VPWR mem_wdata[25] sky130_fd_sc_hd__buf_2
Xoutput130 net130 VGND VGND VPWR VPWR mem_la_wstrb[0] sky130_fd_sc_hd__buf_2
Xoutput185 net185 VGND VGND VPWR VPWR pcpi_rs1[22] sky130_fd_sc_hd__buf_2
XFILLER_153_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput174 net874 VGND VGND VPWR VPWR pcpi_rs1[12] sky130_fd_sc_hd__buf_2
Xoutput163 net163 VGND VGND VPWR VPWR mem_wdata[6] sky130_fd_sc_hd__buf_2
XFILLER_0_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput196 net196 VGND VGND VPWR VPWR pcpi_rs1[3] sky130_fd_sc_hd__buf_2
XFILLER_102_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_34_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07958_ decoded_imm_j\[7\] _03703_ VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__or2_1
X_07889_ net2370 net505 _03723_ net604 VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__a22o_1
X_06909_ reg_pc\[21\] net561 _03322_ net521 VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__a211o_1
XFILLER_56_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09628_ net247 net2173 net376 VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__mux2_1
XFILLER_55_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09559_ net1754 net259 net383 VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__mux2_1
XFILLER_102_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_43_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11452_ clknet_leaf_7_clk _01490_ VGND VGND VPWR VPWR cpuregs\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_8_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11383_ clknet_leaf_152_clk _01421_ VGND VGND VPWR VPWR cpuregs\[7\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_10403_ clknet_leaf_3_clk _00527_ VGND VGND VPWR VPWR cpuregs\[20\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_10334_ clknet_leaf_146_clk _00458_ VGND VGND VPWR VPWR cpuregs\[16\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10265_ clknet_leaf_119_clk _00389_ VGND VGND VPWR VPWR cpuregs\[15\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_10196_ clknet_leaf_72_clk _00320_ VGND VGND VPWR VPWR cpuregs\[9\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout390 _04867_ VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__buf_4
XFILLER_62_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput10 mem_rdata[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_2
Xinput21 mem_rdata[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_2
X_05240_ net714 _01831_ _01832_ _01837_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__a31o_1
XFILLER_128_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05171_ _01760_ _01773_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__or2_1
Xinput32 mem_rdata[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_2
Xhold816 cpuregs\[17\]\[26\] VGND VGND VPWR VPWR net1924 sky130_fd_sc_hd__dlygate4sd3_1
Xhold805 cpuregs\[27\]\[31\] VGND VGND VPWR VPWR net1913 sky130_fd_sc_hd__dlygate4sd3_1
Xhold827 cpuregs\[22\]\[18\] VGND VGND VPWR VPWR net1935 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold838 cpuregs\[11\]\[25\] VGND VGND VPWR VPWR net1946 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold849 cpuregs\[10\]\[7\] VGND VGND VPWR VPWR net1957 sky130_fd_sc_hd__dlygate4sd3_1
X_08930_ net683 _04597_ _04596_ _01557_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__o211a_1
XFILLER_115_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_791 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08861_ net215 net633 _04538_ _04539_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__o22a_1
XFILLER_97_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_96_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07812_ count_instr\[55\] count_instr\[54\] _03677_ VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__and3_1
XFILLER_29_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08792_ cpuregs\[12\]\[17\] cpuregs\[13\]\[17\] cpuregs\[14\]\[17\] cpuregs\[15\]\[17\]
+ net960 net925 VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__mux4_1
XFILLER_69_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07743_ net2279 _03636_ net992 VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__o21ai_1
XFILLER_84_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04955_ instr_sltu instr_slt instr_sltiu instr_slti VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__or4_1
X_07674_ net2305 _03592_ net980 VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__o21ai_1
XFILLER_25_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_36_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09413_ net321 net1872 net397 VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__mux2_1
X_06625_ cpuregs\[12\]\[11\] cpuregs\[13\]\[11\] cpuregs\[14\]\[11\] cpuregs\[15\]\[11\]
+ net773 net737 VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__mux4_1
XFILLER_52_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_101_1949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09344_ mem_rdata_q\[26\] net615 VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_43_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06556_ reg_pc\[8\] net560 _02982_ net520 VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__a211o_1
XFILLER_139_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_138_2540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05507_ _02085_ _02086_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__and2_1
X_09275_ net1158 net847 net483 VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__mux2_1
XFILLER_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06487_ net878 net515 _02915_ net495 VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__o211a_1
XFILLER_148_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08226_ _03725_ _04010_ VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__nor2_1
X_05438_ count_cycle\[29\] net619 net591 _02020_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__o211a_1
XFILLER_21_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08157_ net812 _03720_ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__nand2_1
XFILLER_4_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_151_2751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_2740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_134_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07108_ _03512_ _03513_ net610 VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__a21oi_1
X_05369_ count_instr\[56\] net816 net827 count_cycle\[56\] VGND VGND VPWR VPWR _01957_
+ sky130_fd_sc_hd__a22o_1
XFILLER_134_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08088_ _03870_ _03884_ _03900_ VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__nand3_1
X_07039_ _03444_ _03445_ net654 VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__mux2_1
XFILLER_134_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_106_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10050_ clknet_leaf_15_clk _00174_ VGND VGND VPWR VPWR cpuregs\[13\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_57_34 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_102_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10952_ clknet_leaf_91_clk _01008_ VGND VGND VPWR VPWR decoded_imm\[22\] sky130_fd_sc_hd__dfxtp_2
XFILLER_73_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10883_ clknet_leaf_36_clk _00939_ VGND VGND VPWR VPWR cpuregs\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_145_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11504_ clknet_leaf_110_clk _01542_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dfxtp_1
XFILLER_138_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11435_ clknet_leaf_69_clk _01473_ VGND VGND VPWR VPWR cpuregs\[8\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11366_ clknet_leaf_40_clk _01404_ VGND VGND VPWR VPWR cpuregs\[6\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_74_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_153_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10317_ clknet_leaf_43_clk _00441_ VGND VGND VPWR VPWR cpuregs\[26\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_11297_ clknet_leaf_33_clk _01338_ VGND VGND VPWR VPWR cpuregs\[4\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_98_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10248_ clknet_leaf_53_clk _00372_ VGND VGND VPWR VPWR cpuregs\[27\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10179_ clknet_leaf_4_clk _00303_ VGND VGND VPWR VPWR cpuregs\[9\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_105_2005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_2016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_81_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06410_ net2374 net304 _02841_ VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__o21a_1
X_07390_ net248 net2061 net445 VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__mux2_1
X_06341_ net883 net515 _02774_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__o21a_1
XFILLER_147_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09060_ decoded_imm\[31\] net599 net628 VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__a21o_1
X_06272_ _02707_ _02706_ net568 VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__mux2_4
XFILLER_30_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05223_ net5 _01653_ _01654_ net22 _01761_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__o221a_1
X_08011_ _03828_ _03829_ VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__nor2_1
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold602 cpuregs\[23\]\[31\] VGND VGND VPWR VPWR net1710 sky130_fd_sc_hd__dlygate4sd3_1
Xhold624 cpuregs\[24\]\[26\] VGND VGND VPWR VPWR net1732 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_116_2189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold635 cpuregs\[14\]\[13\] VGND VGND VPWR VPWR net1743 sky130_fd_sc_hd__dlygate4sd3_1
X_05154_ _01742_ net334 _01757_ VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__or3_1
Xhold613 cpuregs\[19\]\[8\] VGND VGND VPWR VPWR net1721 sky130_fd_sc_hd__dlygate4sd3_1
Xhold679 cpuregs\[2\]\[23\] VGND VGND VPWR VPWR net1787 sky130_fd_sc_hd__dlygate4sd3_1
Xhold657 cpuregs\[5\]\[25\] VGND VGND VPWR VPWR net1765 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold646 cpuregs\[23\]\[25\] VGND VGND VPWR VPWR net1754 sky130_fd_sc_hd__dlygate4sd3_1
X_09962_ clknet_leaf_59_clk _00086_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dfxtp_1
Xhold668 cpuregs\[18\]\[15\] VGND VGND VPWR VPWR net1776 sky130_fd_sc_hd__dlygate4sd3_1
X_05085_ net3 net20 net884 VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__mux2_1
XFILLER_143_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08913_ _04586_ _04588_ net480 _04585_ VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__o211a_1
XFILLER_131_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09893_ net1132 VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__clkbuf_1
XFILLER_85_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_794 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08844_ cpuregs\[16\]\[20\] cpuregs\[17\]\[20\] cpuregs\[18\]\[20\] cpuregs\[19\]\[20\]
+ net959 net924 VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__mux4_1
XFILLER_97_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08775_ cpuregs\[28\]\[16\] cpuregs\[29\]\[16\] cpuregs\[30\]\[16\] cpuregs\[31\]\[16\]
+ net965 net930 VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__mux4_1
XFILLER_84_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05987_ reg_out\[14\] reg_next_pc\[14\] net572 VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__mux2_1
XFILLER_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_108_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07726_ net2289 _03625_ net997 VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__o21ai_1
XFILLER_72_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04938_ net726 VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__inv_2
XFILLER_72_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07657_ net249 net1714 net413 VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__mux2_1
X_07588_ net1728 net258 net420 VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__mux2_1
XFILLER_80_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06608_ net641 _03031_ _03032_ _03023_ net722 VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__a221o_1
XFILLER_41_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09327_ net811 _04252_ VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__nor2_1
X_06539_ net488 _02885_ _02964_ net523 VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_153_2802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_117_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09258_ net1722 net236 net404 VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__mux2_1
XFILLER_21_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08209_ net814 _03724_ VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__nand2_1
X_09189_ net2352 _01121_ net331 VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__mux2_1
XFILLER_135_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11220_ clknet_leaf_152_clk _01261_ VGND VGND VPWR VPWR cpuregs\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_135_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11151_ clknet_leaf_120_clk _01192_ VGND VGND VPWR VPWR cpuregs\[23\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_150_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10102_ clknet_leaf_74_clk _00226_ VGND VGND VPWR VPWR cpuregs\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_8_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11082_ clknet_leaf_148_clk _01133_ VGND VGND VPWR VPWR cpuregs\[24\]\[7\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_126_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10033_ clknet_leaf_65_clk _00157_ VGND VGND VPWR VPWR cpuregs\[30\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_102_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10935_ clknet_leaf_105_clk _00991_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dfxtp_1
XFILLER_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10866_ clknet_leaf_127_clk _00922_ VGND VGND VPWR VPWR cpuregs\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_32_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10797_ clknet_leaf_102_clk _00856_ VGND VGND VPWR VPWR instr_lw sky130_fd_sc_hd__dfxtp_1
XFILLER_8_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_144_Right_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11418_ clknet_leaf_15_clk _01456_ VGND VGND VPWR VPWR cpuregs\[8\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11349_ clknet_leaf_148_clk _01387_ VGND VGND VPWR VPWR cpuregs\[6\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_141_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05910_ net544 _02458_ _02460_ VGND VGND VPWR VPWR alu_out\[29\] sky130_fd_sc_hd__a21o_1
X_06890_ _03302_ _03303_ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__nor2_1
X_05841_ _02067_ _02392_ _02212_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_87_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05772_ _02154_ net579 _02332_ _02338_ VGND VGND VPWR VPWR alu_out\[13\] sky130_fd_sc_hd__a211o_1
X_08560_ decoded_imm\[3\] net601 VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__nor2_1
X_07511_ net1379 net297 net428 VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__mux2_1
X_08491_ net75 net1173 net409 VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__mux2_1
X_07442_ net1476 net314 net434 VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__mux2_1
XFILLER_35_586 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07373_ net322 net1718 net442 VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_118_2218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09112_ net719 net6 net613 VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__mux2_1
X_06324_ _02754_ _02755_ _02757_ _02756_ net753 net650 VGND VGND VPWR VPWR _02758_
+ sky130_fd_sc_hd__mux4_1
XFILLER_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_109_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06255_ reg_pc\[28\] _02690_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__xor2_1
X_09043_ cpuregs\[20\]\[31\] cpuregs\[21\]\[31\] cpuregs\[22\]\[31\] cpuregs\[23\]\[31\]
+ net962 net927 VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_131_2429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_117_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06186_ reg_out\[15\] alu_out_q\[15\] net842 VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__mux2_1
X_05206_ reg_pc\[12\] decoded_imm\[12\] VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__or2_1
Xhold410 cpuregs\[20\]\[1\] VGND VGND VPWR VPWR net1518 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_145_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold443 cpuregs\[26\]\[30\] VGND VGND VPWR VPWR net1551 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold421 cpuregs\[14\]\[14\] VGND VGND VPWR VPWR net1529 sky130_fd_sc_hd__dlygate4sd3_1
Xhold454 cpuregs\[11\]\[0\] VGND VGND VPWR VPWR net1562 sky130_fd_sc_hd__dlygate4sd3_1
Xhold432 cpuregs\[2\]\[6\] VGND VGND VPWR VPWR net1540 sky130_fd_sc_hd__dlygate4sd3_1
X_05137_ reg_pc\[7\] decoded_imm\[7\] VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__and2_1
Xhold487 cpuregs\[23\]\[28\] VGND VGND VPWR VPWR net1595 sky130_fd_sc_hd__dlygate4sd3_1
Xhold476 cpuregs\[13\]\[17\] VGND VGND VPWR VPWR net1584 sky130_fd_sc_hd__dlygate4sd3_1
Xhold465 cpuregs\[26\]\[15\] VGND VGND VPWR VPWR net1573 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout934 net936 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__clkbuf_4
XFILLER_132_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout923 net925 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__clkbuf_4
X_05068_ net10 _01656_ net130 net23 _01677_ VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__a221o_1
XFILLER_58_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold498 cpuregs\[30\]\[3\] VGND VGND VPWR VPWR net1606 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout912 net914 VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__clkbuf_2
Xfanout901 _00009_ VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__clkbuf_4
X_09945_ clknet_leaf_132_clk _00069_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dfxtp_2
Xfanout967 net968 VGND VGND VPWR VPWR net967 sky130_fd_sc_hd__buf_2
XFILLER_100_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout956 net957 VGND VGND VPWR VPWR net956 sky130_fd_sc_hd__buf_2
Xfanout945 net952 VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__clkbuf_4
X_09876_ net1124 VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_146_2661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1121 cpuregs\[19\]\[26\] VGND VGND VPWR VPWR net2229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1110 cpuregs\[25\]\[20\] VGND VGND VPWR VPWR net2218 sky130_fd_sc_hd__dlygate4sd3_1
X_08827_ cpuregs\[12\]\[19\] cpuregs\[13\]\[19\] cpuregs\[14\]\[19\] cpuregs\[15\]\[19\]
+ net961 net926 VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__mux4_1
Xhold1132 _00916_ VGND VGND VPWR VPWR net2240 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout989 net990 VGND VGND VPWR VPWR net989 sky130_fd_sc_hd__buf_2
XFILLER_58_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout978 net979 VGND VGND VPWR VPWR net978 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_146_2672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1143 count_instr\[56\] VGND VGND VPWR VPWR net2251 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_85_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1154 count_instr\[19\] VGND VGND VPWR VPWR net2262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1165 count_cycle\[13\] VGND VGND VPWR VPWR net2273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1176 count_cycle\[33\] VGND VGND VPWR VPWR net2284 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_39_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1187 count_cycle\[52\] VGND VGND VPWR VPWR net2295 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1198 count_instr\[14\] VGND VGND VPWR VPWR net2306 sky130_fd_sc_hd__dlygate4sd3_1
X_08758_ cpuregs\[24\]\[15\] cpuregs\[25\]\[15\] cpuregs\[26\]\[15\] cpuregs\[27\]\[15\]
+ net951 net916 VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__mux4_1
X_07709_ net2256 _03613_ _03615_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__a21oi_1
XFILLER_14_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08689_ cpuregs\[16\]\[11\] cpuregs\[17\]\[11\] cpuregs\[18\]\[11\] cpuregs\[19\]\[11\]
+ net941 net906 VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__mux4_1
XFILLER_81_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10720_ clknet_leaf_140_clk _00811_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dfxtp_1
XFILLER_110_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xpicorv32_1050 VGND VGND VPWR VPWR picorv32_1050/HI pcpi_insn[11] sky130_fd_sc_hd__conb_1
Xpicorv32_1061 VGND VGND VPWR VPWR picorv32_1061/HI pcpi_insn[22] sky130_fd_sc_hd__conb_1
X_10651_ clknet_leaf_128_clk _04906_ VGND VGND VPWR VPWR reg_out\[3\] sky130_fd_sc_hd__dfxtp_1
Xpicorv32_1072 VGND VGND VPWR VPWR picorv32_1072/HI trace_data[0] sky130_fd_sc_hd__conb_1
Xpicorv32_1083 VGND VGND VPWR VPWR picorv32_1083/HI trace_data[11] sky130_fd_sc_hd__conb_1
XFILLER_139_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10582_ clknet_leaf_89_clk _00706_ VGND VGND VPWR VPWR reg_next_pc\[31\] sky130_fd_sc_hd__dfxtp_1
Xpicorv32_1094 VGND VGND VPWR VPWR picorv32_1094/HI trace_data[22] sky130_fd_sc_hd__conb_1
XFILLER_139_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11203_ clknet_leaf_43_clk _01244_ VGND VGND VPWR VPWR cpuregs\[29\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_134_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11134_ clknet_leaf_27_clk _01175_ VGND VGND VPWR VPWR cpuregs\[31\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11065_ clknet_leaf_129_clk _01116_ VGND VGND VPWR VPWR mem_rdata_q\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_135_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10016_ clknet_leaf_150_clk _00140_ VGND VGND VPWR VPWR cpuregs\[30\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_69_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10918_ clknet_leaf_30_clk _00974_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_82_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10849_ clknet_leaf_111_clk _00908_ VGND VGND VPWR VPWR decoded_imm_j\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_9_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06040_ decoded_imm_j\[17\] _01111_ net332 VGND VGND VPWR VPWR _00034_ sky130_fd_sc_hd__mux2_1
XFILLER_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_113_2137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_140_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_115_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_114_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07991_ net558 _03811_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__nor2_1
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
X_09730_ net240 net2035 net364 VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__mux2_1
X_06942_ _03325_ _03329_ _03353_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__a21oi_1
X_09661_ net249 net1998 net371 VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_128_2380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06873_ cpuregs\[0\]\[20\] cpuregs\[1\]\[20\] cpuregs\[2\]\[20\] cpuregs\[3\]\[20\]
+ net797 net760 VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__mux4_1
XFILLER_94_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09592_ net1361 net260 net379 VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__mux2_1
X_05824_ _02381_ _02382_ _02384_ VGND VGND VPWR VPWR alu_out\[19\] sky130_fd_sc_hd__o21ai_1
XFILLER_67_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08612_ cpuregs\[12\]\[7\] cpuregs\[13\]\[7\] cpuregs\[14\]\[7\] cpuregs\[15\]\[7\]
+ net943 net908 VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__mux4_1
XFILLER_39_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05755_ _02124_ _02322_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__nor2_1
XFILLER_54_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08543_ _04239_ _04240_ net675 VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__mux2_1
XFILLER_35_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_141_2591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05686_ _02167_ net577 net583 VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__a21o_1
XFILLER_50_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08474_ net86 net1170 net407 VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__mux2_1
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07425_ net1614 net241 net441 VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__mux2_1
XFILLER_149_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07356_ net1359 net251 net448 VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__mux2_1
XFILLER_149_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07287_ net1524 net261 net457 VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__mux2_1
XFILLER_109_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06307_ net888 decoded_imm\[0\] VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__or2_1
X_06238_ reg_out\[25\] alu_out_q\[25\] net843 VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__mux2_1
X_09026_ net224 net633 _04694_ _04695_ VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__o22a_1
XFILLER_105_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold251 cpuregs\[21\]\[27\] VGND VGND VPWR VPWR net1359 sky130_fd_sc_hd__dlygate4sd3_1
X_06169_ _02622_ _02623_ VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__nor2_1
Xhold262 cpuregs\[4\]\[0\] VGND VGND VPWR VPWR net1370 sky130_fd_sc_hd__dlygate4sd3_1
Xhold240 cpuregs\[17\]\[11\] VGND VGND VPWR VPWR net1348 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_148_2701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold284 cpuregs\[31\]\[28\] VGND VGND VPWR VPWR net1392 sky130_fd_sc_hd__dlygate4sd3_1
Xhold295 cpuregs\[31\]\[16\] VGND VGND VPWR VPWR net1403 sky130_fd_sc_hd__dlygate4sd3_1
Xhold273 cpuregs\[24\]\[1\] VGND VGND VPWR VPWR net1381 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_120_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09928_ clknet_leaf_36_clk _00057_ VGND VGND VPWR VPWR cpuregs\[11\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xfanout720 mem_rdata_q\[13\] VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__buf_2
Xfanout742 net745 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__clkbuf_4
Xfanout731 net734 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__clkbuf_4
Xfanout764 net765 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__clkbuf_2
Xfanout775 net777 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__buf_4
Xfanout753 net772 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__buf_2
X_09859_ net253 net2175 net348 VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__mux2_1
Xfanout797 net798 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__buf_4
Xfanout786 net787 VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_29_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_113 net968 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_73_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_102 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10703_ clknet_leaf_69_clk _00795_ VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfxtp_1
XFILLER_14_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10634_ clknet_leaf_85_clk _00758_ VGND VGND VPWR VPWR count_cycle\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_127_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10565_ clknet_leaf_95_clk _00689_ VGND VGND VPWR VPWR reg_next_pc\[14\] sky130_fd_sc_hd__dfxtp_1
X_10496_ clknet_leaf_107_clk _00620_ VGND VGND VPWR VPWR count_instr\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11117_ clknet_leaf_137_clk _01158_ VGND VGND VPWR VPWR cpuregs\[31\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput8 mem_rdata[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_2
X_11048_ clknet_leaf_103_clk _01099_ VGND VGND VPWR VPWR mem_rdata_q\[5\] sky130_fd_sc_hd__dfxtp_1
X_05540_ _02117_ _02119_ VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__and2_1
XFILLER_17_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05471_ net859 net218 VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__nand2_1
XFILLER_32_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08190_ _03722_ _03981_ net686 VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_99_1921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07210_ net1550 net301 net462 VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07141_ net655 _03545_ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__or2_1
X_07072_ net855 _03479_ net307 VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__mux2_1
XFILLER_114_631 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06023_ _01548_ _01603_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__nor2_2
XFILLER_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_101_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07974_ _03793_ _03794_ _03779_ _03784_ VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__a211o_1
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06925_ cpuregs\[16\]\[22\] cpuregs\[17\]\[22\] cpuregs\[18\]\[22\] cpuregs\[19\]\[22\]
+ net802 net765 VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__mux4_1
X_09713_ net312 net2057 net361 VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_143_2620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06856_ _03167_ _03197_ _03220_ _03247_ VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__and4_1
XFILLER_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09644_ net321 net1893 net369 VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__mux2_1
X_05807_ _02047_ _02368_ _02369_ VGND VGND VPWR VPWR alu_out\[17\] sky130_fd_sc_hd__o21ai_1
XFILLER_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06787_ cpuregs\[20\]\[17\] cpuregs\[21\]\[17\] cpuregs\[22\]\[17\] cpuregs\[23\]\[17\]
+ net791 net754 VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__mux4_1
XFILLER_24_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09575_ net1406 net337 net377 VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__mux2_1
X_05738_ _02136_ _02307_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__or2_1
X_08526_ cpuregs\[20\]\[0\] cpuregs\[21\]\[0\] cpuregs\[22\]\[0\] cpuregs\[23\]\[0\]
+ net944 net909 VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__mux4_1
X_08457_ net759 _04188_ _04189_ _04190_ net652 VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__o221a_1
X_05669_ net578 net543 _02132_ VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__a21oi_1
XFILLER_51_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07408_ net1743 net313 net439 VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__mux2_1
XFILLER_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_583 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08388_ count_cycle\[46\] count_cycle\[47\] _04135_ VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__and3_1
X_07339_ net1275 net324 net446 VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__mux2_1
X_10350_ clknet_leaf_42_clk _00474_ VGND VGND VPWR VPWR cpuregs\[16\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09009_ cpuregs\[16\]\[29\] cpuregs\[17\]\[29\] cpuregs\[18\]\[29\] cpuregs\[19\]\[29\]
+ net973 net938 VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__mux4_1
X_10281_ clknet_leaf_25_clk _00405_ VGND VGND VPWR VPWR cpuregs\[15\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_642 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout550 _04747_ VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__buf_2
Xfanout572 net574 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__clkbuf_4
Xfanout561 net562 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout583 net584 VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__buf_2
Xfanout594 _01652_ VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__buf_4
XFILLER_46_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10617_ clknet_leaf_110_clk _00741_ VGND VGND VPWR VPWR count_cycle\[34\] sky130_fd_sc_hd__dfxtp_1
X_10548_ clknet_leaf_63_clk _00672_ VGND VGND VPWR VPWR reg_pc\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_94_1840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10479_ clknet_leaf_86_clk _00603_ VGND VGND VPWR VPWR count_instr\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_84_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04971_ _00580_ _01596_ VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__or2_1
XFILLER_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_2058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06710_ _03129_ _03130_ net647 VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__mux2_1
XFILLER_65_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07690_ net2276 _03602_ net985 VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__o21ai_1
XFILLER_53_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06641_ decoded_imm\[12\] net874 VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__nand2_1
XFILLER_64_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_2269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09360_ net836 decoded_imm_j\[18\] net615 mem_rdata_q\[18\] VGND VGND VPWR VPWR _04842_
+ sky130_fd_sc_hd__a22o_1
XFILLER_80_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06572_ cpuregs\[24\]\[9\] cpuregs\[25\]\[9\] cpuregs\[26\]\[9\] cpuregs\[27\]\[9\]
+ net774 net738 VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__mux4_1
X_09291_ net1146 net104 net484 VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__mux2_1
X_05523_ net855 net222 VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__or2_1
X_08311_ _04090_ net994 VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__and2b_1
XFILLER_33_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08242_ _03585_ _04041_ _04042_ VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_103_1980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05454_ _02029_ _02031_ _02034_ _02035_ VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__or4_1
XANTENNA_13 _02581_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_32_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_57 net187 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_35 _04877_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_24 _03562_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_46 net88 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08173_ _03964_ _03969_ _03976_ net686 VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__a31o_1
X_05385_ net590 _01970_ _01971_ net857 net708 VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__a32o_1
XANTENNA_79 net640 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_68 net425 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07124_ _03526_ _03527_ _03528_ _03529_ net730 net725 VGND VGND VPWR VPWR _03530_
+ sky130_fd_sc_hd__mux4_2
XFILLER_9_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07055_ cpuregs\[28\]\[27\] cpuregs\[29\]\[27\] cpuregs\[30\]\[27\] cpuregs\[31\]\[27\]
+ net804 net767 VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__mux4_1
XFILLER_106_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06006_ net860 _02505_ net637 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__mux2_1
Xoutput142 net142 VGND VGND VPWR VPWR mem_wdata[16] sky130_fd_sc_hd__buf_2
Xoutput120 net120 VGND VGND VPWR VPWR mem_la_wdata[30] sky130_fd_sc_hd__buf_2
Xoutput131 net131 VGND VGND VPWR VPWR mem_la_wstrb[1] sky130_fd_sc_hd__buf_2
Xoutput186 net860 VGND VGND VPWR VPWR pcpi_rs1[23] sky130_fd_sc_hd__buf_2
Xoutput153 net153 VGND VGND VPWR VPWR mem_wdata[26] sky130_fd_sc_hd__buf_2
Xoutput175 net175 VGND VGND VPWR VPWR pcpi_rs1[13] sky130_fd_sc_hd__buf_2
Xoutput164 net164 VGND VGND VPWR VPWR mem_wdata[7] sky130_fd_sc_hd__buf_2
XFILLER_0_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput197 net881 VGND VGND VPWR VPWR pcpi_rs1[4] sky130_fd_sc_hd__buf_2
XFILLER_75_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07957_ decoded_imm_j\[7\] _03703_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__nand2_1
X_06908_ net724 _03318_ _03321_ net518 VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__o211a_1
X_07888_ _02685_ reg_next_pc\[26\] net573 VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_39_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09627_ net253 net2123 net376 VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__mux2_1
X_06839_ cpuregs\[0\]\[19\] cpuregs\[1\]\[19\] cpuregs\[2\]\[19\] cpuregs\[3\]\[19\]
+ net795 net758 VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__mux4_1
XFILLER_83_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09558_ net1422 net263 net382 VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__mux2_1
XFILLER_43_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08509_ mem_do_prefetch _02731_ _04209_ _04210_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__o31a_1
XFILLER_12_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09489_ net1633 net278 net391 VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__mux2_1
XFILLER_134_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11451_ clknet_leaf_4_clk _01489_ VGND VGND VPWR VPWR cpuregs\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_10402_ clknet_leaf_14_clk _00526_ VGND VGND VPWR VPWR cpuregs\[20\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_11382_ clknet_leaf_146_clk _01420_ VGND VGND VPWR VPWR cpuregs\[7\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10333_ clknet_leaf_149_clk _00457_ VGND VGND VPWR VPWR cpuregs\[16\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10264_ clknet_leaf_15_clk _00388_ VGND VGND VPWR VPWR cpuregs\[15\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_10195_ clknet_leaf_70_clk _00319_ VGND VGND VPWR VPWR cpuregs\[9\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout391 net392 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__clkbuf_8
XFILLER_66_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout380 _04870_ VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkbuf_8
XFILLER_143_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput11 mem_rdata[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
Xinput22 mem_rdata[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_2
X_05170_ net32 _01653_ _01654_ net18 _01761_ VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__o221a_1
Xinput33 mem_ready VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
XFILLER_143_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold817 cpuregs\[28\]\[27\] VGND VGND VPWR VPWR net1925 sky130_fd_sc_hd__dlygate4sd3_1
Xhold828 cpuregs\[22\]\[19\] VGND VGND VPWR VPWR net1936 sky130_fd_sc_hd__dlygate4sd3_1
Xhold806 cpuregs\[19\]\[14\] VGND VGND VPWR VPWR net1914 sky130_fd_sc_hd__dlygate4sd3_1
Xhold839 cpuregs\[13\]\[27\] VGND VGND VPWR VPWR net1947 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08860_ decoded_imm\[20\] net598 net628 VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__a21o_1
XFILLER_97_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07811_ count_instr\[54\] _03677_ count_instr\[55\] VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__a21o_1
XFILLER_85_827 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08791_ net210 net632 _04472_ _04473_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__o22a_1
XFILLER_111_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07742_ count_instr\[29\] count_instr\[28\] count_instr\[27\] _03632_ VGND VGND VPWR
+ VPWR _03637_ sky130_fd_sc_hd__and4_1
X_04954_ instr_ori instr_xori instr_addi instr_bgeu VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__or4_1
XFILLER_38_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_93_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07673_ count_instr\[4\] count_instr\[3\] count_instr\[2\] _03589_ VGND VGND VPWR
+ VPWR _03593_ sky130_fd_sc_hd__and4_1
XFILLER_80_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06624_ _03043_ _03044_ _03047_ net523 VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__a211o_1
X_09412_ net324 net2209 net397 VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__mux2_1
X_09343_ net2371 net553 net401 _04833_ VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__o22a_1
XFILLER_12_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06555_ net722 _02978_ _02981_ net516 VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_43_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05506_ net854 net223 VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__or2_1
X_09274_ net2332 _04808_ _04811_ _04812_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__a22o_1
X_06486_ net198 net506 VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__or2_1
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08225_ _03724_ _03725_ _04005_ VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__and3_1
X_05437_ count_instr\[29\] net823 net624 _02019_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__a211o_1
XFILLER_153_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08156_ _03962_ _03963_ net991 VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__o21a_1
X_05368_ net17 net597 net587 VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__a21o_1
XFILLER_5_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_151_2752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_2741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_134_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07107_ _03487_ _03490_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__nand2_1
X_05299_ _01890_ _01891_ VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__nand2b_1
X_08087_ _03847_ _03852_ _03861_ _03871_ _03860_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__a32o_1
X_07038_ _03438_ _03439_ net656 VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__mux2_1
XFILLER_115_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08989_ _04659_ _04660_ net481 _04657_ VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__o211a_1
XFILLER_102_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10951_ clknet_leaf_91_clk _01007_ VGND VGND VPWR VPWR decoded_imm\[23\] sky130_fd_sc_hd__dfxtp_2
XFILLER_90_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10882_ clknet_leaf_37_clk _00938_ VGND VGND VPWR VPWR cpuregs\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11503_ clknet_leaf_35_clk _01541_ VGND VGND VPWR VPWR cpuregs\[10\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11434_ clknet_leaf_49_clk _01472_ VGND VGND VPWR VPWR cpuregs\[8\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_144_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11365_ clknet_leaf_38_clk _01403_ VGND VGND VPWR VPWR cpuregs\[6\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_74_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_100_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_100_clk sky130_fd_sc_hd__clkbuf_8
X_10316_ clknet_leaf_35_clk _00440_ VGND VGND VPWR VPWR cpuregs\[26\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11296_ clknet_leaf_22_clk _01337_ VGND VGND VPWR VPWR cpuregs\[4\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10247_ clknet_leaf_17_clk _00371_ VGND VGND VPWR VPWR cpuregs\[27\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_654 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10178_ clknet_leaf_18_clk _00302_ VGND VGND VPWR VPWR cpuregs\[9\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_105_2006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_105_2017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_705 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06340_ _01553_ net515 VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__nand2_1
XFILLER_147_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06271_ reg_out\[31\] alu_out_q\[31\] net843 VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__mux2_1
XFILLER_147_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05222_ _01807_ _01810_ _01819_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__a21o_1
X_08010_ _03825_ _03827_ net832 VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_41_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold603 cpuregs\[17\]\[20\] VGND VGND VPWR VPWR net1711 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_133_2460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold614 cpuregs\[1\]\[31\] VGND VGND VPWR VPWR net1722 sky130_fd_sc_hd__dlygate4sd3_1
X_05153_ _01755_ _01756_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__and2_1
Xhold636 cpuregs\[11\]\[4\] VGND VGND VPWR VPWR net1744 sky130_fd_sc_hd__dlygate4sd3_1
Xhold625 cpuregs\[18\]\[8\] VGND VGND VPWR VPWR net1733 sky130_fd_sc_hd__dlygate4sd3_1
Xhold669 cpuregs\[12\]\[18\] VGND VGND VPWR VPWR net1777 sky130_fd_sc_hd__dlygate4sd3_1
X_09961_ clknet_leaf_59_clk _00085_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dfxtp_2
Xhold647 cpuregs\[17\]\[14\] VGND VGND VPWR VPWR net1755 sky130_fd_sc_hd__dlygate4sd3_1
Xhold658 cpuregs\[3\]\[5\] VGND VGND VPWR VPWR net1766 sky130_fd_sc_hd__dlygate4sd3_1
X_05084_ _01689_ _01692_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__xnor2_1
X_08912_ net892 _04587_ net667 VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__a21o_1
XFILLER_134_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09892_ net1115 VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__clkbuf_1
X_08843_ cpuregs\[20\]\[20\] cpuregs\[21\]\[20\] cpuregs\[22\]\[20\] cpuregs\[23\]\[20\]
+ net963 net928 VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__mux4_1
X_08774_ cpuregs\[16\]\[16\] cpuregs\[17\]\[16\] cpuregs\[18\]\[16\] cpuregs\[19\]\[16\]
+ net965 net930 VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__mux4_1
X_05986_ net873 _02495_ net635 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__mux2_2
XFILLER_27_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07725_ count_instr\[23\] count_instr\[22\] _03618_ _03622_ VGND VGND VPWR VPWR _03626_
+ sky130_fd_sc_hd__and4_1
XFILLER_72_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04937_ net732 VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_0_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07656_ net253 net1807 net413 VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__mux2_1
X_07587_ net1245 net259 net421 VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__mux2_1
XFILLER_80_384 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06607_ net647 _03021_ net727 VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__o21a_1
XFILLER_41_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09326_ reg_sh\[1\] reg_sh\[0\] _02744_ _01647_ VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__a31o_1
X_06538_ net878 net506 VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_153_2803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09257_ net1199 net241 net405 VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__mux2_1
XFILLER_21_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08208_ _03724_ _04005_ net686 VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__o21ai_1
X_06469_ net649 _02898_ _02897_ net722 VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__o211a_1
XFILLER_135_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09188_ mem_rdata_q\[27\] net20 net611 VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__mux2_1
XFILLER_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_135_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08139_ _03903_ _03909_ _03910_ _03944_ _03947_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__a41o_1
XFILLER_150_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_578 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11150_ clknet_leaf_122_clk _01191_ VGND VGND VPWR VPWR cpuregs\[23\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_10101_ clknet_leaf_76_clk _00225_ VGND VGND VPWR VPWR cpuregs\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_134_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11081_ clknet_leaf_144_clk _01132_ VGND VGND VPWR VPWR cpuregs\[24\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_10032_ clknet_leaf_51_clk _00156_ VGND VGND VPWR VPWR cpuregs\[30\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_149_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_149_clk sky130_fd_sc_hd__clkbuf_8
X_10934_ clknet_leaf_105_clk _00990_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_27_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10865_ clknet_leaf_123_clk _00921_ VGND VGND VPWR VPWR cpuregs\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10796_ clknet_leaf_98_clk net2363 VGND VGND VPWR VPWR instr_lh sky130_fd_sc_hd__dfxtp_1
XFILLER_33_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11417_ clknet_leaf_2_clk _01455_ VGND VGND VPWR VPWR cpuregs\[8\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11348_ clknet_leaf_126_clk _01386_ VGND VGND VPWR VPWR cpuregs\[6\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_113_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11279_ clknet_leaf_120_clk _01320_ VGND VGND VPWR VPWR cpuregs\[4\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_635 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05840_ _02066_ net576 _02397_ _02398_ VGND VGND VPWR VPWR alu_out\[21\] sky130_fd_sc_hd__a211o_1
XFILLER_94_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05771_ _02155_ _02336_ _02337_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__a21oi_1
X_07510_ net1573 net301 net427 VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__mux2_1
XFILLER_35_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08490_ net74 net1194 net409 VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__mux2_1
XFILLER_81_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07441_ net1335 net319 net434 VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__mux2_1
XFILLER_35_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07372_ net325 net2030 net442 VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__mux2_1
XFILLER_148_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_118_2219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09111_ net2368 net500 _04750_ _04757_ VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__a22o_1
X_06323_ cpuregs\[0\]\[1\] cpuregs\[1\]\[1\] net788 VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__mux2_1
XFILLER_31_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09042_ net226 net633 _04709_ _04710_ VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__o22a_1
XFILLER_117_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06254_ reg_out\[28\] alu_out_q\[28\] net843 VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__mux2_1
X_06185_ net309 net1973 net476 VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__mux2_1
X_05205_ _01801_ _01804_ VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__and2_1
Xhold411 cpuregs\[7\]\[2\] VGND VGND VPWR VPWR net1519 sky130_fd_sc_hd__dlygate4sd3_1
Xhold400 cpuregs\[24\]\[6\] VGND VGND VPWR VPWR net1508 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_132_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold444 cpuregs\[20\]\[16\] VGND VGND VPWR VPWR net1552 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold433 cpuregs\[19\]\[19\] VGND VGND VPWR VPWR net1541 sky130_fd_sc_hd__dlygate4sd3_1
Xhold422 cpuregs\[20\]\[12\] VGND VGND VPWR VPWR net1530 sky130_fd_sc_hd__dlygate4sd3_1
X_05136_ _01723_ _01729_ _01730_ _01728_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__a31oi_1
Xhold466 cpuregs\[2\]\[26\] VGND VGND VPWR VPWR net1574 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_145_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold455 cpuregs\[14\]\[24\] VGND VGND VPWR VPWR net1563 sky130_fd_sc_hd__dlygate4sd3_1
Xhold477 cpuregs\[3\]\[2\] VGND VGND VPWR VPWR net1585 sky130_fd_sc_hd__dlygate4sd3_1
Xhold488 cpuregs\[14\]\[27\] VGND VGND VPWR VPWR net1596 sky130_fd_sc_hd__dlygate4sd3_1
Xhold499 cpuregs\[21\]\[21\] VGND VGND VPWR VPWR net1607 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout924 net925 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__clkbuf_4
Xfanout902 net905 VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__buf_4
X_05067_ net887 net698 _01676_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__and3_1
Xfanout913 net914 VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__clkbuf_4
X_09944_ clknet_leaf_129_clk _00031_ VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__dfxtp_4
Xfanout935 net936 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__clkbuf_2
Xhold1100 cpuregs\[8\]\[21\] VGND VGND VPWR VPWR net2208 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout968 net975 VGND VGND VPWR VPWR net968 sky130_fd_sc_hd__clkbuf_4
Xfanout946 net949 VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_5_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout957 _00007_ VGND VGND VPWR VPWR net957 sky130_fd_sc_hd__clkbuf_2
X_09875_ decoded_imm_j\[3\] _01117_ net330 VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__mux2_1
XFILLER_38_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_2662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1111 cpuregs\[7\]\[24\] VGND VGND VPWR VPWR net2219 sky130_fd_sc_hd__dlygate4sd3_1
X_08826_ net212 net632 _04505_ _04506_ VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__o22a_1
XFILLER_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1133 reg_sh\[1\] VGND VGND VPWR VPWR net2241 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1122 cpuregs\[6\]\[6\] VGND VGND VPWR VPWR net2230 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout979 net983 VGND VGND VPWR VPWR net979 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_146_2673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold1144 count_instr\[47\] VGND VGND VPWR VPWR net2252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1155 count_cycle\[9\] VGND VGND VPWR VPWR net2263 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1166 count_instr\[8\] VGND VGND VPWR VPWR net2274 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_72_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08757_ cpuregs\[28\]\[15\] cpuregs\[29\]\[15\] cpuregs\[30\]\[15\] cpuregs\[31\]\[15\]
+ net951 net916 VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__mux4_1
Xhold1188 count_instr\[42\] VGND VGND VPWR VPWR net2296 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_54_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05969_ reg_out\[5\] reg_next_pc\[5\] net570 VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__mux2_1
XFILLER_39_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1177 count_instr\[36\] VGND VGND VPWR VPWR net2285 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1199 count_instr\[2\] VGND VGND VPWR VPWR net2307 sky130_fd_sc_hd__dlygate4sd3_1
X_07708_ count_instr\[17\] _03613_ net995 VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__o21ai_1
XFILLER_54_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08688_ cpuregs\[20\]\[11\] cpuregs\[21\]\[11\] cpuregs\[22\]\[11\] cpuregs\[23\]\[11\]
+ net941 net906 VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__mux4_1
X_07639_ net324 net1538 net410 VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_598 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10650_ clknet_leaf_128_clk _04903_ VGND VGND VPWR VPWR reg_out\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xpicorv32_1040 VGND VGND VPWR VPWR picorv32_1040/HI pcpi_insn[1] sky130_fd_sc_hd__conb_1
X_09309_ net2357 net487 VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__or2_1
XFILLER_10_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xpicorv32_1051 VGND VGND VPWR VPWR picorv32_1051/HI pcpi_insn[12] sky130_fd_sc_hd__conb_1
Xpicorv32_1084 VGND VGND VPWR VPWR picorv32_1084/HI trace_data[12] sky130_fd_sc_hd__conb_1
Xpicorv32_1062 VGND VGND VPWR VPWR picorv32_1062/HI pcpi_insn[23] sky130_fd_sc_hd__conb_1
Xpicorv32_1095 VGND VGND VPWR VPWR picorv32_1095/HI trace_data[23] sky130_fd_sc_hd__conb_1
X_10581_ clknet_leaf_80_clk _00705_ VGND VGND VPWR VPWR reg_next_pc\[30\] sky130_fd_sc_hd__dfxtp_1
Xpicorv32_1073 VGND VGND VPWR VPWR picorv32_1073/HI trace_data[1] sky130_fd_sc_hd__conb_1
XFILLER_139_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11202_ clknet_leaf_44_clk _01243_ VGND VGND VPWR VPWR cpuregs\[29\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_11133_ clknet_leaf_45_clk _01174_ VGND VGND VPWR VPWR cpuregs\[31\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11064_ clknet_leaf_111_clk _01115_ VGND VGND VPWR VPWR mem_rdata_q\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10015_ clknet_leaf_148_clk _00139_ VGND VGND VPWR VPWR cpuregs\[30\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10917_ clknet_leaf_8_clk _00973_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dfxtp_1
XFILLER_60_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_800 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10848_ clknet_leaf_99_clk _00907_ VGND VGND VPWR VPWR decoded_imm_j\[11\] sky130_fd_sc_hd__dfxtp_2
XFILLER_32_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10779_ clknet_leaf_64_clk alu_out\[26\] VGND VGND VPWR VPWR alu_out_q\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_13_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_113_2138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_97_1882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_141_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07990_ net832 _03801_ _03802_ _03809_ _03810_ VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__o32a_1
X_06941_ _03351_ _03352_ VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__nand2_1
X_09660_ net252 net1756 net371 VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_128_2381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06872_ cpuregs\[4\]\[20\] cpuregs\[5\]\[20\] cpuregs\[6\]\[20\] cpuregs\[7\]\[20\]
+ net792 net755 VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__mux4_1
X_08611_ cpuregs\[0\]\[7\] cpuregs\[1\]\[7\] cpuregs\[2\]\[7\] cpuregs\[3\]\[7\] net942
+ net907 VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__mux4_1
X_09591_ net1246 net266 net378 VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__mux2_1
X_05823_ _02069_ net582 _02383_ _02070_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__o22a_1
XFILLER_67_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05754_ _02133_ _02136_ _02137_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__o21a_1
X_08542_ cpuregs\[0\]\[1\] cpuregs\[1\]\[1\] cpuregs\[2\]\[1\] cpuregs\[3\]\[1\] net956
+ net921 VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_145_Left_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_141_2592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08473_ net407 VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__inv_2
X_07424_ net1485 net245 net441 VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__mux2_1
XFILLER_62_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05685_ _02260_ _02261_ _02262_ VGND VGND VPWR VPWR alu_out\[2\] sky130_fd_sc_hd__or3_1
XFILLER_23_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07355_ net1323 net255 net447 VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__mux2_1
XFILLER_31_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_136_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07286_ net1621 net265 net457 VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__mux2_1
XFILLER_109_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06306_ net888 decoded_imm\[0\] VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__nand2_1
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_148_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06237_ net265 net2203 net478 VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__mux2_1
X_09025_ decoded_imm\[29\] net599 net628 VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__a21o_1
XFILLER_132_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold252 cpuregs\[25\]\[21\] VGND VGND VPWR VPWR net1360 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold230 cpuregs\[26\]\[31\] VGND VGND VPWR VPWR net1338 sky130_fd_sc_hd__dlygate4sd3_1
X_06168_ reg_pc\[11\] reg_pc\[10\] _02615_ VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__and3_1
XFILLER_2_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold241 cpuregs\[27\]\[2\] VGND VGND VPWR VPWR net1349 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 cpuregs\[2\]\[28\] VGND VGND VPWR VPWR net1393 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_148_2702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold274 cpuregs\[29\]\[19\] VGND VGND VPWR VPWR net1382 sky130_fd_sc_hd__dlygate4sd3_1
Xhold263 cpuregs\[23\]\[15\] VGND VGND VPWR VPWR net1371 sky130_fd_sc_hd__dlygate4sd3_1
X_06099_ _02562_ _02563_ _02566_ net896 net891 VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__a221oi_2
X_05119_ _01722_ _01725_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__xor2_1
Xhold296 cpuregs\[26\]\[11\] VGND VGND VPWR VPWR net1404 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09927_ clknet_leaf_25_clk _00056_ VGND VGND VPWR VPWR cpuregs\[11\]\[19\] sky130_fd_sc_hd__dfxtp_1
Xfanout721 mem_rdata_q\[12\] VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__buf_2
Xfanout732 net734 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__clkbuf_2
Xfanout710 cpu_state\[4\] VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__clkbuf_4
XFILLER_49_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout765 net772 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__clkbuf_4
Xfanout754 net757 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout743 net745 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__clkbuf_2
Xfanout776 net777 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__buf_4
X_09858_ net257 net1823 net348 VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__mux2_1
Xfanout798 net802 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__buf_4
XFILLER_73_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout787 net809 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_29_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09789_ net268 net1871 net356 VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__mux2_1
XFILLER_105_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08809_ cpuregs\[16\]\[18\] cpuregs\[17\]\[18\] cpuregs\[18\]\[18\] cpuregs\[19\]\[18\]
+ net959 net924 VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__mux4_1
XFILLER_85_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_114 net990 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_103 _01736_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_121_30 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10702_ clknet_leaf_49_clk _00794_ VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_80_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_80_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_64_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10633_ clknet_leaf_84_clk _00757_ VGND VGND VPWR VPWR count_cycle\[50\] sky130_fd_sc_hd__dfxtp_1
X_10564_ clknet_leaf_95_clk _00688_ VGND VGND VPWR VPWR reg_next_pc\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10495_ clknet_leaf_108_clk _00619_ VGND VGND VPWR VPWR count_instr\[38\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11116_ clknet_leaf_100_clk _00023_ VGND VGND VPWR VPWR cpu_state\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11047_ clknet_leaf_103_clk _01098_ VGND VGND VPWR VPWR mem_rdata_q\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput9 mem_rdata[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_2
XFILLER_49_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_71_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_71_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_45_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05470_ _02047_ _02048_ VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__or2_1
XFILLER_33_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07140_ cpuregs\[28\]\[30\] cpuregs\[29\]\[30\] cpuregs\[30\]\[30\] cpuregs\[31\]\[30\]
+ net807 net770 VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_99_1922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07071_ net525 _03457_ _03458_ _03460_ _03478_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__o41a_1
XFILLER_126_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06022_ net195 _02513_ net636 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__mux2_1
XFILLER_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_101_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07973_ _03779_ _03784_ _03793_ _03794_ VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__o211a_1
X_09712_ net316 net1799 net361 VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__mux2_1
XFILLER_142_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06924_ cpuregs\[20\]\[22\] cpuregs\[21\]\[22\] cpuregs\[22\]\[22\] cpuregs\[23\]\[22\]
+ net798 net761 VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__mux4_1
XFILLER_68_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_2621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06855_ _03220_ _03221_ _03245_ _03246_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__a31o_1
X_09643_ net324 net2156 net369 VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_153_Left_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05806_ _02049_ net581 _02366_ _02367_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__o22a_1
XFILLER_83_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09574_ net1242 net341 net377 VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__mux2_1
X_06786_ cpuregs\[0\]\[17\] cpuregs\[1\]\[17\] cpuregs\[2\]\[17\] cpuregs\[3\]\[17\]
+ net791 net754 VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__mux4_1
XFILLER_35_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08525_ net664 _04223_ VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__nand2_1
X_05737_ _02135_ _02294_ _02137_ _02133_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__o211a_1
X_08456_ cpuregs\[27\]\[31\] net794 net759 VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__a21bo_1
X_05668_ is_compare net584 net579 net577 VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_46_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08387_ count_cycle\[46\] _04135_ count_cycle\[47\] VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__a21o_1
X_07407_ net1980 net318 net438 VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__mux2_1
XFILLER_51_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05599_ net877 _01564_ _02139_ _02178_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__a31o_1
X_07338_ net1293 net327 net446 VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__mux2_1
X_07269_ net1417 net339 net454 VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__mux2_1
X_09008_ cpuregs\[20\]\[29\] cpuregs\[21\]\[29\] cpuregs\[22\]\[29\] cpuregs\[23\]\[29\]
+ net972 net937 VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__mux4_1
X_10280_ clknet_leaf_54_clk _00404_ VGND VGND VPWR VPWR cpuregs\[15\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout540 _02584_ VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__buf_2
Xfanout551 _04747_ VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__buf_2
Xfanout573 net574 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__clkbuf_4
Xfanout562 net563 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__clkbuf_4
XFILLER_76_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout584 _02242_ VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__buf_2
Xfanout595 _01652_ VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__clkbuf_2
XFILLER_86_593 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_53_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_53_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
X_10616_ clknet_leaf_109_clk _00740_ VGND VGND VPWR VPWR count_cycle\[33\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_12_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10547_ clknet_leaf_63_clk _00671_ VGND VGND VPWR VPWR reg_pc\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10478_ clknet_leaf_85_clk _00602_ VGND VGND VPWR VPWR count_instr\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_142_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_04970_ net629 _01591_ _01595_ VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_139_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_108_2059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06640_ decoded_imm\[12\] net874 VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__or2_1
XFILLER_2_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_44_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_44_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_17_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06571_ cpuregs\[28\]\[9\] cpuregs\[29\]\[9\] cpuregs\[30\]\[9\] cpuregs\[31\]\[9\]
+ net773 net737 VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__mux4_1
XFILLER_45_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05522_ net855 net222 VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__nand2_1
X_08310_ count_cycle\[16\] count_cycle\[17\] count_cycle\[18\] _04085_ VGND VGND VPWR
+ VPWR _04090_ sky130_fd_sc_hd__and4_1
X_09290_ net1145 net103 net485 VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__mux2_1
XANTENNA_14 _02581_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08241_ net690 reg_next_pc\[29\] net547 _03726_ VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_103_1981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05453_ net709 net194 VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_31_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_47 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 _04878_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_25 _03568_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08172_ _03964_ _03969_ _03976_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__a21oi_1
X_05384_ count_cycle\[25\] net618 VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__or2_1
XANTENNA_58 net205 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_20_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_69 net427 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07123_ _03518_ _03519_ net736 VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__mux2_1
XFILLER_146_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07054_ cpuregs\[8\]\[27\] cpuregs\[9\]\[27\] cpuregs\[10\]\[27\] cpuregs\[11\]\[27\]
+ net803 net766 VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__mux4_1
XFILLER_134_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput110 net110 VGND VGND VPWR VPWR mem_la_wdata[21] sky130_fd_sc_hd__buf_2
X_06005_ reg_out\[23\] reg_next_pc\[23\] net573 VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__mux2_1
Xoutput121 net121 VGND VGND VPWR VPWR mem_la_wdata[31] sky130_fd_sc_hd__buf_2
Xoutput132 net132 VGND VGND VPWR VPWR mem_la_wstrb[2] sky130_fd_sc_hd__buf_2
Xoutput143 net143 VGND VGND VPWR VPWR mem_wdata[17] sky130_fd_sc_hd__buf_2
XFILLER_114_440 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput154 net154 VGND VGND VPWR VPWR mem_wdata[27] sky130_fd_sc_hd__buf_2
Xoutput176 net176 VGND VGND VPWR VPWR pcpi_rs1[14] sky130_fd_sc_hd__buf_2
XFILLER_88_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput165 net165 VGND VGND VPWR VPWR mem_wdata[8] sky130_fd_sc_hd__buf_2
XFILLER_0_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput187 net187 VGND VGND VPWR VPWR pcpi_rs1[24] sky130_fd_sc_hd__buf_2
XFILLER_114_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_101_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput198 net880 VGND VGND VPWR VPWR pcpi_rs1[5] sky130_fd_sc_hd__buf_2
X_07956_ decoded_imm_j\[7\] _03703_ VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__and2_1
X_06907_ _03312_ _03319_ _03320_ net642 net639 VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__a221o_1
XFILLER_101_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07887_ reg_pc\[25\] net505 _03722_ net605 VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_83_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09626_ net257 net1896 net375 VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__mux2_1
X_06838_ cpuregs\[4\]\[19\] cpuregs\[5\]\[19\] cpuregs\[6\]\[19\] cpuregs\[7\]\[19\]
+ net793 net757 VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__mux4_1
XFILLER_83_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09557_ net1665 net267 net383 VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__mux2_1
X_06769_ _03185_ _03186_ net654 VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__mux2_1
XFILLER_71_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09488_ net1486 net282 net391 VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_35_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_35_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_70_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08508_ net835 net717 net707 net848 VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__or4b_1
X_08439_ cpuregs\[12\]\[31\] cpuregs\[13\]\[31\] cpuregs\[14\]\[31\] cpuregs\[15\]\[31\]
+ net792 net756 VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__mux4_1
XFILLER_12_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11450_ clknet_leaf_12_clk _01488_ VGND VGND VPWR VPWR cpuregs\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_109_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10401_ clknet_leaf_2_clk _00525_ VGND VGND VPWR VPWR cpuregs\[20\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_11381_ clknet_leaf_149_clk _01419_ VGND VGND VPWR VPWR cpuregs\[7\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10332_ clknet_leaf_125_clk _00456_ VGND VGND VPWR VPWR cpuregs\[16\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_59_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_771 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10263_ clknet_leaf_55_clk _00387_ VGND VGND VPWR VPWR cpuregs\[27\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10194_ clknet_leaf_49_clk _00318_ VGND VGND VPWR VPWR cpuregs\[9\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_858 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout392 _04867_ VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__buf_4
Xfanout370 net371 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__clkbuf_8
Xfanout381 net384 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__clkbuf_8
XFILLER_86_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_26_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
Xinput12 mem_rdata[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
XFILLER_116_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput23 mem_rdata[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput34 resetn VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_2
Xhold807 cpuregs\[18\]\[28\] VGND VGND VPWR VPWR net1915 sky130_fd_sc_hd__dlygate4sd3_1
Xhold818 cpuregs\[29\]\[18\] VGND VGND VPWR VPWR net1926 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold829 cpuregs\[28\]\[10\] VGND VGND VPWR VPWR net1937 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_97_600 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07810_ net2280 _03677_ _03679_ VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__a21oi_1
X_08790_ decoded_imm\[16\] net598 net627 VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__a21o_1
X_07741_ _03636_ net1001 _03635_ VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__and3b_1
XFILLER_85_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_04953_ instr_bltu instr_bge instr_blt instr_bne VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__or4_1
XFILLER_38_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07672_ _03592_ net980 _03591_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__and3b_1
X_06623_ net488 _02965_ _03046_ _03045_ VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__a31o_1
XFILLER_52_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09411_ net326 net1654 net397 VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__mux2_1
X_09342_ mem_rdata_q\[27\] net616 VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__and2_1
XFILLER_80_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_17_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
X_06554_ net641 _02979_ _02980_ _02973_ net638 VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__a221o_1
X_05505_ net854 net223 VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__nand2_1
XFILLER_21_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09273_ net850 _01571_ _04809_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__a21bo_1
X_06485_ net883 net506 net488 _02913_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__o211a_1
X_08224_ _04024_ _04025_ VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__or2_1
X_05436_ count_instr\[61\] net816 net825 count_cycle\[61\] VGND VGND VPWR VPWR _02019_
+ sky130_fd_sc_hd__a22o_1
XFILLER_147_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08155_ net689 reg_next_pc\[22\] net546 _03719_ VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__a22o_1
X_05367_ _01950_ _01953_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_151_2753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_2742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07106_ _03510_ _03511_ VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__nor2_1
XFILLER_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05298_ reg_pc\[19\] decoded_imm\[19\] VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__nand2_1
X_08086_ _03809_ _03817_ _03849_ _03898_ VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__nand4_1
X_07037_ _03442_ _03443_ net654 VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__mux2_1
XFILLER_115_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08988_ net894 _04658_ net667 VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__a21o_1
XFILLER_75_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07939_ net834 _03762_ _03763_ VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__or3_1
XFILLER_113_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10950_ clknet_leaf_91_clk _01006_ VGND VGND VPWR VPWR decoded_imm\[24\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_3_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10881_ clknet_leaf_23_clk _00937_ VGND VGND VPWR VPWR cpuregs\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09609_ net326 net1561 net373 VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__mux2_1
XFILLER_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11502_ clknet_leaf_74_clk _01540_ VGND VGND VPWR VPWR cpuregs\[10\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_11433_ clknet_leaf_68_clk _01471_ VGND VGND VPWR VPWR cpuregs\[8\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11364_ clknet_leaf_33_clk _01402_ VGND VGND VPWR VPWR cpuregs\[6\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_99_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11295_ clknet_leaf_33_clk _01336_ VGND VGND VPWR VPWR cpuregs\[4\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_10315_ clknet_leaf_22_clk _00439_ VGND VGND VPWR VPWR cpuregs\[26\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10246_ clknet_leaf_11_clk _00370_ VGND VGND VPWR VPWR cpuregs\[27\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_121_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_67_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10177_ clknet_leaf_2_clk _00301_ VGND VGND VPWR VPWR cpuregs\[9\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_89_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_717 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06270_ reg_pc\[31\] _02703_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__xnor2_1
XFILLER_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05221_ _01807_ _01810_ _01819_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__nand3_1
XFILLER_8_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_133_2461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold626 cpuregs\[9\]\[17\] VGND VGND VPWR VPWR net1734 sky130_fd_sc_hd__dlygate4sd3_1
Xhold615 instr_sra VGND VGND VPWR VPWR net1723 sky130_fd_sc_hd__dlygate4sd3_1
X_05152_ reg_pc\[8\] decoded_imm\[8\] VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__nand2_1
Xhold604 cpuregs\[19\]\[3\] VGND VGND VPWR VPWR net1712 sky130_fd_sc_hd__dlygate4sd3_1
Xmax_cap334 _01745_ VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__buf_1
Xhold659 cpuregs\[10\]\[23\] VGND VGND VPWR VPWR net1767 sky130_fd_sc_hd__dlygate4sd3_1
Xhold648 cpuregs\[22\]\[27\] VGND VGND VPWR VPWR net1756 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09960_ clknet_leaf_19_clk _00084_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dfxtp_2
Xclkbuf_leaf_6_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
Xhold637 cpuregs\[3\]\[1\] VGND VGND VPWR VPWR net1745 sky130_fd_sc_hd__dlygate4sd3_1
X_05083_ _01690_ _01691_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__nand2_1
X_08911_ _04576_ _04577_ net680 VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__mux2_1
X_09891_ net1137 VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__clkbuf_1
X_08842_ net213 net632 _04520_ _04521_ VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__o22a_1
XFILLER_58_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08773_ cpuregs\[20\]\[16\] cpuregs\[21\]\[16\] cpuregs\[22\]\[16\] cpuregs\[23\]\[16\]
+ net965 net930 VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__mux4_1
X_05985_ reg_out\[13\] reg_next_pc\[13\] net569 VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__mux2_1
XFILLER_150_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_04936_ net219 VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__inv_2
X_07724_ _03625_ net997 _03624_ VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_0_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07655_ net255 net1924 net412 VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__mux2_1
XFILLER_65_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06606_ _03029_ _03030_ net646 VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__mux2_1
X_07586_ net1292 net264 net420 VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__mux2_1
XFILLER_80_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06537_ net874 net515 VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__or2_1
X_09325_ _01554_ _04821_ _04820_ VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__a21o_1
X_09256_ net1205 net246 net405 VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__mux2_1
XFILLER_138_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06468_ cpuregs\[28\]\[5\] cpuregs\[29\]\[5\] cpuregs\[30\]\[5\] cpuregs\[31\]\[5\]
+ net776 net740 VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__mux4_1
X_08207_ _03724_ _04005_ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__and2_1
X_05419_ reg_pc\[28\] decoded_imm\[28\] VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__nand2_1
XFILLER_147_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09187_ net2360 _01120_ net331 VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__mux2_1
X_06399_ net643 _02826_ _02830_ _02822_ VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__a31o_1
XFILLER_135_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08138_ _03910_ _03922_ _03944_ _03946_ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__a31o_1
XFILLER_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08069_ _03882_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_56_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10100_ clknet_leaf_70_clk _00224_ VGND VGND VPWR VPWR cpuregs\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11080_ clknet_leaf_142_clk _01131_ VGND VGND VPWR VPWR cpuregs\[24\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_150_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10031_ clknet_leaf_45_clk _00155_ VGND VGND VPWR VPWR cpuregs\[30\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_8_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_496 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_91_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10933_ clknet_leaf_106_clk _00989_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dfxtp_1
XFILLER_44_566 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10864_ clknet_leaf_121_clk _00920_ VGND VGND VPWR VPWR cpuregs\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_27_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_599 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10795_ clknet_leaf_102_clk _00854_ VGND VGND VPWR VPWR instr_lb sky130_fd_sc_hd__dfxtp_1
XFILLER_12_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11416_ clknet_leaf_138_clk _01454_ VGND VGND VPWR VPWR cpuregs\[8\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_706 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11347_ clknet_leaf_124_clk _01385_ VGND VGND VPWR VPWR cpuregs\[6\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11278_ clknet_leaf_114_clk _01319_ VGND VGND VPWR VPWR cpuregs\[4\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_10229_ clknet_leaf_71_clk _00353_ VGND VGND VPWR VPWR cpuregs\[14\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold1 cpuregs\[0\]\[29\] VGND VGND VPWR VPWR net1109 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_94_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05770_ _02155_ _02336_ net544 VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__o21ai_1
XFILLER_81_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_503 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07440_ net1432 net322 net434 VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07371_ net328 net1829 net442 VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__mux2_1
X_09110_ net719 net720 net721 VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__and3_1
XFILLER_50_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06322_ cpuregs\[2\]\[1\] cpuregs\[3\]\[1\] net788 VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__mux2_1
X_09041_ decoded_imm\[30\] net599 net628 VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__a21o_1
XFILLER_31_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06253_ net253 net2232 net479 VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__mux2_1
XFILLER_117_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06184_ _02635_ _02636_ net567 VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__mux2_1
Xhold401 cpuregs\[4\]\[13\] VGND VGND VPWR VPWR net1509 sky130_fd_sc_hd__dlygate4sd3_1
X_05204_ _01780_ _01791_ _01803_ _01789_ VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__o211a_1
XFILLER_144_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold434 cpuregs\[27\]\[28\] VGND VGND VPWR VPWR net1542 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold445 cpuregs\[1\]\[12\] VGND VGND VPWR VPWR net1553 sky130_fd_sc_hd__dlygate4sd3_1
Xhold423 cpuregs\[12\]\[8\] VGND VGND VPWR VPWR net1531 sky130_fd_sc_hd__dlygate4sd3_1
X_05135_ _01731_ _01733_ _01740_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__o21bai_1
Xhold412 cpuregs\[30\]\[0\] VGND VGND VPWR VPWR net1520 sky130_fd_sc_hd__dlygate4sd3_1
Xhold456 cpuregs\[26\]\[23\] VGND VGND VPWR VPWR net1564 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold478 cpuregs\[20\]\[20\] VGND VGND VPWR VPWR net1586 sky130_fd_sc_hd__dlygate4sd3_1
Xhold467 cpuregs\[20\]\[18\] VGND VGND VPWR VPWR net1575 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout903 net905 VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__buf_2
Xfanout925 net933 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__clkbuf_4
X_05066_ net2 net19 net885 VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_5_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09943_ clknet_leaf_118_clk _00030_ VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__dfxtp_2
Xhold489 cpuregs\[17\]\[8\] VGND VGND VPWR VPWR net1597 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout914 net917 VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__buf_2
Xfanout936 net940 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__buf_2
Xfanout958 net960 VGND VGND VPWR VPWR net958 sky130_fd_sc_hd__buf_4
Xfanout947 net949 VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_5_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09874_ decoded_imm_j\[2\] _01116_ net330 VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__mux2_1
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1112 cpuregs\[9\]\[26\] VGND VGND VPWR VPWR net2220 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout969 net971 VGND VGND VPWR VPWR net969 sky130_fd_sc_hd__buf_4
XFILLER_112_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1123 cpuregs\[7\]\[31\] VGND VGND VPWR VPWR net2231 sky130_fd_sc_hd__dlygate4sd3_1
X_08825_ decoded_imm\[18\] net598 net627 VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__a21o_1
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1101 cpuregs\[18\]\[10\] VGND VGND VPWR VPWR net2209 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_146_2674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1145 count_cycle\[51\] VGND VGND VPWR VPWR net2253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1134 instr_bltu VGND VGND VPWR VPWR net2242 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_57_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1156 count_cycle\[4\] VGND VGND VPWR VPWR net2264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1167 count_instr\[33\] VGND VGND VPWR VPWR net2275 sky130_fd_sc_hd__dlygate4sd3_1
X_08756_ cpuregs\[16\]\[15\] cpuregs\[17\]\[15\] cpuregs\[18\]\[15\] cpuregs\[19\]\[15\]
+ net951 net916 VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__mux4_1
Xhold1178 count_instr\[45\] VGND VGND VPWR VPWR net2286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1189 count_instr\[11\] VGND VGND VPWR VPWR net2297 sky130_fd_sc_hd__dlygate4sd3_1
X_05968_ net881 _02486_ net634 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__mux2_1
XFILLER_38_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05899_ _02449_ _02450_ net830 VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__mux2_1
X_07707_ _03613_ _03614_ VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__nor2_1
X_08687_ cpuregs\[0\]\[11\] cpuregs\[1\]\[11\] cpuregs\[2\]\[11\] cpuregs\[3\]\[11\]
+ net946 net911 VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__mux4_1
X_04919_ net718 VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_24_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07638_ net327 net1329 net410 VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07569_ net1927 net341 net418 VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xpicorv32_1030 VGND VGND VPWR VPWR picorv32_1030/HI eoi[27] sky130_fd_sc_hd__conb_1
Xpicorv32_1052 VGND VGND VPWR VPWR picorv32_1052/HI pcpi_insn[13] sky130_fd_sc_hd__conb_1
X_09308_ net130 net407 _04813_ _04204_ VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__o211a_1
Xpicorv32_1041 VGND VGND VPWR VPWR picorv32_1041/HI pcpi_insn[2] sky130_fd_sc_hd__conb_1
XFILLER_139_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xpicorv32_1074 VGND VGND VPWR VPWR picorv32_1074/HI trace_data[2] sky130_fd_sc_hd__conb_1
Xpicorv32_1085 VGND VGND VPWR VPWR picorv32_1085/HI trace_data[13] sky130_fd_sc_hd__conb_1
X_10580_ clknet_leaf_80_clk _00704_ VGND VGND VPWR VPWR reg_next_pc\[29\] sky130_fd_sc_hd__dfxtp_1
Xpicorv32_1063 VGND VGND VPWR VPWR picorv32_1063/HI pcpi_insn[24] sky130_fd_sc_hd__conb_1
Xpicorv32_1096 VGND VGND VPWR VPWR picorv32_1096/HI trace_data[24] sky130_fd_sc_hd__conb_1
XFILLER_108_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09239_ net1553 net316 net402 VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__mux2_1
XFILLER_6_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11201_ clknet_leaf_35_clk _01242_ VGND VGND VPWR VPWR cpuregs\[29\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_11132_ clknet_leaf_16_clk _01173_ VGND VGND VPWR VPWR cpuregs\[31\]\[15\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold990 cpuregs\[16\]\[27\] VGND VGND VPWR VPWR net2098 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_135_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11063_ clknet_leaf_99_clk _01114_ VGND VGND VPWR VPWR mem_rdata_q\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10014_ clknet_leaf_145_clk _00138_ VGND VGND VPWR VPWR cpuregs\[30\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_86_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_69_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10916_ clknet_leaf_38_clk _00972_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dfxtp_1
XFILLER_72_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10847_ clknet_leaf_91_clk _00906_ VGND VGND VPWR VPWR decoded_imm_j\[18\] sky130_fd_sc_hd__dfxtp_1
X_10778_ clknet_leaf_64_clk alu_out\[25\] VGND VGND VPWR VPWR alu_out_q\[25\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_57_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_754 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_113_2139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_114_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06940_ decoded_imm\[23\] net859 VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__nand2_1
X_06871_ cpuregs\[24\]\[20\] cpuregs\[25\]\[20\] cpuregs\[26\]\[20\] cpuregs\[27\]\[20\]
+ net797 net760 VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_66_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05822_ _02069_ net576 net585 VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__a21oi_1
XFILLER_67_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08610_ cpuregs\[4\]\[7\] cpuregs\[5\]\[7\] cpuregs\[6\]\[7\] cpuregs\[7\]\[7\] net943
+ net908 VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__mux4_1
X_09590_ net1388 net269 net379 VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_128_2382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05753_ _02121_ _02124_ _02135_ _02139_ VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__or4_1
X_08541_ cpuregs\[4\]\[1\] cpuregs\[5\]\[1\] cpuregs\[6\]\[1\] cpuregs\[7\]\[1\] net955
+ net920 VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_141_2582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08472_ net487 _04204_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__and2b_1
X_05684_ _02126_ net581 net584 _02128_ VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__a2bb2o_1
X_07423_ net1484 net247 net441 VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_141_2593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07354_ net1408 net259 net448 VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__mux2_1
XFILLER_10_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07285_ net1787 net267 net456 VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__mux2_1
XFILLER_109_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06305_ net851 _01608_ net606 _01604_ _02738_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__a221o_4
X_09024_ _04692_ _04693_ net481 _04690_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__o211a_1
X_06236_ _02675_ _02678_ net568 VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold220 cpuregs\[27\]\[23\] VGND VGND VPWR VPWR net1328 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold253 cpuregs\[29\]\[25\] VGND VGND VPWR VPWR net1361 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold242 cpuregs\[27\]\[15\] VGND VGND VPWR VPWR net1350 sky130_fd_sc_hd__dlygate4sd3_1
X_06167_ reg_pc\[11\] reg_pc\[10\] _02615_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__and3_1
XFILLER_2_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold231 cpuregs\[26\]\[4\] VGND VGND VPWR VPWR net1339 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_148_2703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold286 cpuregs\[2\]\[21\] VGND VGND VPWR VPWR net1394 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold264 cpuregs\[14\]\[16\] VGND VGND VPWR VPWR net1372 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_105_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout700 net702 VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__buf_2
X_06098_ _02564_ _02565_ net674 VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__mux2_1
X_05118_ _01723_ _01724_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__nand2_1
Xhold275 cpuregs\[1\]\[0\] VGND VGND VPWR VPWR net1383 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_132_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09926_ clknet_leaf_34_clk _00055_ VGND VGND VPWR VPWR cpuregs\[11\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_05049_ net715 net704 net708 VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__nor3_1
Xfanout722 net725 VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__clkbuf_8
Xfanout711 net716 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__clkbuf_4
Xhold297 cpuregs\[15\]\[12\] VGND VGND VPWR VPWR net1405 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout733 net734 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__clkbuf_4
Xfanout766 net767 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__clkbuf_4
Xfanout755 net757 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout744 net745 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__clkbuf_4
X_09857_ net262 net2172 net348 VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__mux2_1
Xfanout799 net801 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__buf_4
XFILLER_86_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout788 net789 VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__clkbuf_4
Xfanout777 net784 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__clkbuf_4
X_09788_ net272 net1984 net355 VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__mux2_1
X_08808_ cpuregs\[20\]\[18\] cpuregs\[21\]\[18\] cpuregs\[22\]\[18\] cpuregs\[23\]\[18\]
+ net959 net924 VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__mux4_1
XFILLER_73_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_104 _02483_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08739_ cpuregs\[4\]\[14\] cpuregs\[5\]\[14\] cpuregs\[6\]\[14\] cpuregs\[7\]\[14\]
+ net948 net913 VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__mux4_1
XFILLER_65_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10701_ clknet_leaf_49_clk _00793_ VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_64_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_889 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10632_ clknet_leaf_84_clk _00756_ VGND VGND VPWR VPWR count_cycle\[49\] sky130_fd_sc_hd__dfxtp_1
X_10563_ clknet_leaf_134_clk _00687_ VGND VGND VPWR VPWR reg_next_pc\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10494_ clknet_leaf_108_clk _00618_ VGND VGND VPWR VPWR count_instr\[37\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_146_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11115_ clknet_leaf_98_clk _00022_ VGND VGND VPWR VPWR cpu_state\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_150_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11046_ clknet_leaf_103_clk _01097_ VGND VGND VPWR VPWR mem_rdata_q\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_92_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_801 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_99_1912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07070_ reg_pc\[27\] net562 _03477_ net519 net522 VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__a221o_1
XFILLER_145_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06021_ reg_out\[31\] reg_next_pc\[31\] net575 VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__mux2_1
XFILLER_126_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_114_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07972_ decoded_imm_j\[8\] _03704_ VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__or2_1
X_09711_ net321 net1836 net361 VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__mux2_1
X_06923_ cpuregs\[0\]\[22\] cpuregs\[1\]\[22\] cpuregs\[2\]\[22\] cpuregs\[3\]\[22\]
+ net798 net761 VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__mux4_1
XFILLER_110_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_2622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06854_ net864 _02740_ VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__and2_1
X_09642_ net327 net1535 net369 VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__mux2_1
X_06785_ cpuregs\[4\]\[17\] cpuregs\[5\]\[17\] cpuregs\[6\]\[17\] cpuregs\[7\]\[17\]
+ net791 net754 VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__mux4_1
X_05805_ _02049_ net576 net585 VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__a21oi_1
X_09573_ net1544 net471 net377 VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__mux2_1
X_05736_ _02305_ _02306_ _02301_ VGND VGND VPWR VPWR alu_out\[9\] sky130_fd_sc_hd__o21ai_1
XFILLER_35_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08524_ _04221_ _04222_ net671 VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__mux2_1
XFILLER_35_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08455_ net794 cpuregs\[26\]\[31\] VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__and2b_1
X_05667_ is_compare net584 net581 net578 VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__and4bb_4
XTAP_TAPCELL_ROW_46_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08386_ net2266 _04135_ _04137_ VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__a21oi_1
X_05598_ net234 net876 VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__and2b_1
XFILLER_50_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07406_ net1271 net320 net438 VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__mux2_1
XFILLER_149_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07337_ net2114 net338 net446 VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__mux2_1
XFILLER_109_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_109_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07268_ net1540 net470 net454 VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__mux2_1
XFILLER_151_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09007_ net223 net633 _04676_ _04677_ VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__o22a_1
X_06219_ _02663_ _02664_ VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__nor2_1
X_07199_ net1244 net494 net465 VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__mux2_1
XFILLER_151_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_120_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_13 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout530 net531 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__clkbuf_2
Xfanout563 _02784_ VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__clkbuf_4
Xfanout574 _02483_ VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__buf_2
XFILLER_59_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09909_ clknet_leaf_119_clk _00038_ VGND VGND VPWR VPWR cpuregs\[11\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xfanout552 net556 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout596 net597 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__buf_2
Xfanout585 _02242_ VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__buf_2
XFILLER_76_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_132_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_132_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10615_ clknet_leaf_110_clk _00739_ VGND VGND VPWR VPWR count_cycle\[32\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_12_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_561 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10546_ clknet_leaf_63_clk _00670_ VGND VGND VPWR VPWR reg_pc\[26\] sky130_fd_sc_hd__dfxtp_2
XFILLER_6_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10477_ clknet_leaf_85_clk _00601_ VGND VGND VPWR VPWR count_instr\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_97_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11029_ clknet_leaf_46_clk _01085_ VGND VGND VPWR VPWR cpuregs\[19\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_65_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06570_ cpuregs\[8\]\[9\] cpuregs\[9\]\[9\] cpuregs\[10\]\[9\] cpuregs\[11\]\[9\]
+ net773 net737 VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__mux4_1
X_05521_ net855 net222 VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__and2_1
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08240_ net839 _04037_ _04038_ _04039_ _04040_ VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_103_1982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05452_ count_cycle\[30\] net619 net591 _02033_ VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__o211a_1
XFILLER_33_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_37 _04878_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_48 net97 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08171_ _03976_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__inv_2
XANTENNA_15 _02582_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_26 _03573_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07122_ _03522_ _03523_ net736 VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__mux2_1
X_05383_ net827 count_cycle\[57\] net623 _01969_ VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__a211o_1
XANTENNA_59 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_107_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07053_ cpuregs\[12\]\[27\] cpuregs\[13\]\[27\] cpuregs\[14\]\[27\] cpuregs\[15\]\[27\]
+ net803 net766 VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__mux4_1
XFILLER_134_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput100 net100 VGND VGND VPWR VPWR mem_la_wdata[12] sky130_fd_sc_hd__buf_2
X_06004_ net185 _02504_ net637 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__mux2_1
Xoutput111 net111 VGND VGND VPWR VPWR mem_la_wdata[22] sky130_fd_sc_hd__buf_2
Xoutput133 net133 VGND VGND VPWR VPWR mem_la_wstrb[3] sky130_fd_sc_hd__buf_2
Xoutput122 net122 VGND VGND VPWR VPWR mem_la_wdata[3] sky130_fd_sc_hd__buf_2
XFILLER_114_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput155 net155 VGND VGND VPWR VPWR mem_wdata[28] sky130_fd_sc_hd__buf_2
Xoutput144 net144 VGND VGND VPWR VPWR mem_wdata[18] sky130_fd_sc_hd__buf_2
Xoutput166 net166 VGND VGND VPWR VPWR mem_wdata[9] sky130_fd_sc_hd__buf_2
Xoutput177 net177 VGND VGND VPWR VPWR pcpi_rs1[15] sky130_fd_sc_hd__buf_2
Xoutput188 net188 VGND VGND VPWR VPWR pcpi_rs1[25] sky130_fd_sc_hd__buf_2
XFILLER_153_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput199 net879 VGND VGND VPWR VPWR pcpi_rs1[6] sky130_fd_sc_hd__buf_2
XFILLER_102_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07955_ _03777_ _03778_ net977 VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__o21a_1
X_06906_ _03316_ _03317_ net653 VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__mux2_1
XFILLER_56_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09625_ net261 net1837 net376 VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__mux2_1
X_07886_ _02680_ reg_next_pc\[25\] net574 VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__mux2_2
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_907 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06837_ net607 _03249_ _03252_ net525 VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__a211o_1
XFILLER_71_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09556_ net1739 net271 net382 VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__mux2_1
X_06768_ net654 _03180_ net642 VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__o21a_1
XFILLER_102_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06699_ net867 net514 VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__or2_1
X_09487_ net1468 net285 net391 VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__mux2_1
X_08507_ _01650_ _01651_ net717 VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__o21a_1
X_05719_ _02140_ net577 net583 VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__a21o_1
X_08438_ _04169_ _04170_ _04171_ net525 VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_61_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_483 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08369_ count_cycle\[40\] _04125_ net986 VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__o21ai_1
XFILLER_149_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_137_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_12_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11380_ clknet_leaf_126_clk _01418_ VGND VGND VPWR VPWR cpuregs\[7\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_10400_ clknet_leaf_14_clk _00524_ VGND VGND VPWR VPWR cpuregs\[20\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_10331_ clknet_leaf_122_clk _00455_ VGND VGND VPWR VPWR cpuregs\[16\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_10262_ clknet_leaf_64_clk _00386_ VGND VGND VPWR VPWR cpuregs\[27\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_76_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10193_ clknet_leaf_68_clk _00317_ VGND VGND VPWR VPWR cpuregs\[9\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_133_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_455 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_143_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout360 _04876_ VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__buf_4
Xfanout371 net372 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_8
Xfanout382 net383 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__clkbuf_8
XFILLER_94_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout393 net396 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__buf_4
XFILLER_74_542 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_148_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput13 mem_rdata[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_2
Xinput24 mem_rdata[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_2
XFILLER_7_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10529_ clknet_leaf_133_clk _00653_ VGND VGND VPWR VPWR reg_pc\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold808 cpuregs\[20\]\[6\] VGND VGND VPWR VPWR net1916 sky130_fd_sc_hd__dlygate4sd3_1
Xhold819 cpuregs\[25\]\[7\] VGND VGND VPWR VPWR net1927 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_97_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07740_ count_instr\[28\] count_instr\[27\] _03632_ VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__and3_1
XFILLER_84_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04952_ instr_srli instr_lhu instr_sb instr_lw VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__or4_1
XFILLER_38_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07671_ count_instr\[3\] count_instr\[2\] _03589_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_36_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06622_ net871 net513 VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__or2_1
X_09410_ net336 net1733 net397 VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09341_ decoded_imm\[28\] net554 net401 _04832_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__o22a_1
XFILLER_80_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06553_ net644 _02971_ net726 VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__o21a_1
X_05504_ net854 net223 VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__and2_1
XFILLER_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_2532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09272_ net2317 _04808_ _04810_ _04811_ VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__a22o_1
X_06484_ net875 net515 VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__or2_1
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_2543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08223_ _04012_ _04017_ _04022_ net686 VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__a31o_1
X_05435_ net22 net596 net588 VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__a21o_1
XFILLER_147_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08154_ net557 _03961_ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__nor2_1
X_05366_ _01950_ _01953_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_151_2754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_151_2743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07105_ decoded_imm\[29\] net192 VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__and2_1
X_08085_ _03847_ _03861_ _03870_ _03884_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__and4_1
X_07036_ cpuregs\[16\]\[26\] cpuregs\[17\]\[26\] cpuregs\[18\]\[26\] cpuregs\[19\]\[26\]
+ net800 net763 VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__mux4_1
X_05297_ reg_pc\[19\] decoded_imm\[19\] VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__nor2_1
XFILLER_106_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_76_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_54_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08987_ net683 _04651_ _04650_ net663 VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__o211a_1
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_102_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07938_ _03700_ _03701_ _03744_ VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__and3_1
X_07869_ _02646_ reg_next_pc\[17\] net572 VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_3_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10880_ clknet_leaf_31_clk _00936_ VGND VGND VPWR VPWR cpuregs\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_56_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09608_ net335 net1435 net373 VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__mux2_1
X_09539_ net1473 net474 net381 VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__mux2_1
XFILLER_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11501_ clknet_leaf_72_clk _01539_ VGND VGND VPWR VPWR cpuregs\[10\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_129_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11432_ clknet_leaf_51_clk _01470_ VGND VGND VPWR VPWR cpuregs\[8\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11363_ clknet_leaf_26_clk _01401_ VGND VGND VPWR VPWR cpuregs\[6\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_74_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10314_ clknet_leaf_25_clk _00438_ VGND VGND VPWR VPWR cpuregs\[26\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_11294_ clknet_leaf_29_clk _01335_ VGND VGND VPWR VPWR cpuregs\[4\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_10245_ clknet_leaf_10_clk _00369_ VGND VGND VPWR VPWR cpuregs\[27\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10176_ clknet_leaf_14_clk _00300_ VGND VGND VPWR VPWR cpuregs\[9\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_105_2019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_2008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_148_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_147_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05220_ _01817_ _01818_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__nand2_1
XFILLER_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05151_ reg_pc\[8\] decoded_imm\[8\] VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__or2_1
XFILLER_8_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold627 cpuregs\[25\]\[16\] VGND VGND VPWR VPWR net1735 sky130_fd_sc_hd__dlygate4sd3_1
Xhold605 cpuregs\[24\]\[13\] VGND VGND VPWR VPWR net1713 sky130_fd_sc_hd__dlygate4sd3_1
Xhold616 cpuregs\[31\]\[10\] VGND VGND VPWR VPWR net1724 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold638 cpuregs\[4\]\[23\] VGND VGND VPWR VPWR net1746 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold649 cpuregs\[5\]\[8\] VGND VGND VPWR VPWR net1757 sky130_fd_sc_hd__dlygate4sd3_1
X_05082_ reg_pc\[3\] decoded_imm\[3\] VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__or2_1
X_08910_ net903 _04582_ _04581_ net661 VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__o211a_1
XFILLER_131_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09890_ net1140 VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__clkbuf_1
XFILLER_112_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08841_ decoded_imm\[19\] net598 net627 VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__a21o_1
XFILLER_97_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08772_ net209 net631 _04454_ _04455_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__o22a_1
X_05984_ net874 _02494_ net635 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__mux2_2
X_04935_ net224 VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__inv_2
X_07723_ count_instr\[22\] _03618_ _03622_ VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__and3_1
X_07654_ net261 net1737 net413 VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06605_ cpuregs\[0\]\[10\] cpuregs\[1\]\[10\] cpuregs\[2\]\[10\] cpuregs\[3\]\[10\]
+ net780 net744 VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__mux4_1
XFILLER_25_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07585_ net1402 net270 net420 VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__mux2_1
XFILLER_41_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09324_ _04234_ decoded_imm_j\[11\] net811 VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__mux2_1
XFILLER_34_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06536_ _02909_ _02911_ _02935_ _02960_ _02934_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__a311o_2
XFILLER_43_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09255_ net1941 net247 net405 VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__mux2_1
XFILLER_21_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06467_ net731 _02896_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__or2_1
X_08206_ _04008_ _04009_ net1002 VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__o21a_1
X_05418_ reg_pc\[28\] decoded_imm\[28\] VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__or2_1
X_09186_ mem_rdata_q\[26\] net19 net611 VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__mux2_1
X_06398_ net733 _02827_ _02829_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__a21o_1
XFILLER_146_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05349_ _01936_ _01937_ VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__nand2_1
X_08137_ net813 _03717_ _03945_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__a21o_1
XFILLER_135_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08068_ decoded_imm_j\[16\] _03712_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_56_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07019_ net856 net303 VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__and2_1
X_10030_ clknet_leaf_43_clk _00154_ VGND VGND VPWR VPWR cpuregs\[30\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_106 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10932_ clknet_leaf_107_clk _00988_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dfxtp_1
XFILLER_44_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_140_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10863_ clknet_leaf_121_clk _00919_ VGND VGND VPWR VPWR cpuregs\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_27_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10794_ clknet_leaf_102_clk _00853_ VGND VGND VPWR VPWR instr_jalr sky130_fd_sc_hd__dfxtp_2
XFILLER_137_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11415_ clknet_leaf_149_clk _01453_ VGND VGND VPWR VPWR cpuregs\[8\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_2170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11346_ clknet_leaf_122_clk _01384_ VGND VGND VPWR VPWR cpuregs\[6\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_99_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11277_ clknet_leaf_137_clk _01318_ VGND VGND VPWR VPWR cpuregs\[4\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10228_ clknet_leaf_71_clk _00352_ VGND VGND VPWR VPWR cpuregs\[14\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10159_ clknet_leaf_45_clk _00283_ VGND VGND VPWR VPWR cpuregs\[21\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold2 cpuregs\[0\]\[30\] VGND VGND VPWR VPWR net1110 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07370_ net337 net2129 net442 VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__mux2_1
X_06321_ cpuregs\[6\]\[1\] cpuregs\[7\]\[1\] net788 VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__mux2_1
X_09040_ net894 _04705_ _04708_ net481 VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__o211a_1
X_06252_ _02688_ _02691_ net568 VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__mux2_1
X_05203_ _01768_ _01802_ _01792_ _01781_ VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__a211o_1
X_06183_ reg_pc\[14\] _02632_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__xor2_1
Xhold402 cpuregs\[25\]\[12\] VGND VGND VPWR VPWR net1510 sky130_fd_sc_hd__dlygate4sd3_1
Xhold435 cpuregs\[27\]\[24\] VGND VGND VPWR VPWR net1543 sky130_fd_sc_hd__dlygate4sd3_1
Xhold413 cpuregs\[25\]\[15\] VGND VGND VPWR VPWR net1521 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold424 cpuregs\[24\]\[0\] VGND VGND VPWR VPWR net1532 sky130_fd_sc_hd__dlygate4sd3_1
X_05134_ net705 net879 _01736_ net702 _01739_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__a221o_1
XFILLER_132_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold468 cpuregs\[30\]\[27\] VGND VGND VPWR VPWR net1576 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_117_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold457 cpuregs\[12\]\[17\] VGND VGND VPWR VPWR net1565 sky130_fd_sc_hd__dlygate4sd3_1
Xhold446 cpuregs\[28\]\[12\] VGND VGND VPWR VPWR net1554 sky130_fd_sc_hd__dlygate4sd3_1
X_09942_ clknet_leaf_118_clk _00029_ VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__dfxtp_4
X_05065_ net713 _01673_ _01674_ _01675_ VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__a31o_1
Xfanout904 net905 VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__buf_4
Xhold479 cpuregs\[12\]\[5\] VGND VGND VPWR VPWR net1587 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout915 net917 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__clkbuf_4
Xfanout937 net940 VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__clkbuf_4
Xfanout926 net933 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__clkbuf_4
Xfanout948 net949 VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_5_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09873_ decoded_imm_j\[1\] _01115_ net330 VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__mux2_1
Xhold1113 cpuregs\[10\]\[29\] VGND VGND VPWR VPWR net2221 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1124 cpuregs\[11\]\[27\] VGND VGND VPWR VPWR net2232 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_140_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout959 net960 VGND VGND VPWR VPWR net959 sky130_fd_sc_hd__buf_4
X_08824_ _04503_ _04504_ net480 _04501_ VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__o211a_1
Xhold1102 cpuregs\[3\]\[10\] VGND VGND VPWR VPWR net2210 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_57_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1135 count_cycle\[27\] VGND VGND VPWR VPWR net2243 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1157 count_instr\[48\] VGND VGND VPWR VPWR net2265 sky130_fd_sc_hd__dlygate4sd3_1
X_08755_ net673 _04438_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__or2_1
XFILLER_73_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1146 latched_is_lh VGND VGND VPWR VPWR net2254 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1179 count_instr\[60\] VGND VGND VPWR VPWR net2287 sky130_fd_sc_hd__dlygate4sd3_1
X_07706_ net2315 _03612_ net995 VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__o21ai_1
XFILLER_66_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1168 count_instr\[10\] VGND VGND VPWR VPWR net2276 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_54_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05967_ reg_out\[4\] reg_next_pc\[4\] net570 VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__mux2_1
X_05898_ _02108_ _02420_ _02231_ VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__a21oi_1
XFILLER_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04918_ mem_do_rinst VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__inv_2
X_08686_ cpuregs\[4\]\[11\] cpuregs\[5\]\[11\] cpuregs\[6\]\[11\] cpuregs\[7\]\[11\]
+ net946 net911 VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__mux4_1
XFILLER_26_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07637_ net336 net1597 net410 VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07568_ net1274 net472 net418 VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1042 VGND VGND VPWR VPWR picorv32_1042/HI pcpi_insn[3] sky130_fd_sc_hd__conb_1
XFILLER_70_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09307_ net2347 net487 VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__or2_1
X_06519_ cpuregs\[4\]\[7\] cpuregs\[5\]\[7\] cpuregs\[6\]\[7\] cpuregs\[7\]\[7\] net775
+ net739 VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__mux4_1
Xpicorv32_1020 VGND VGND VPWR VPWR picorv32_1020/HI eoi[17] sky130_fd_sc_hd__conb_1
Xpicorv32_1031 VGND VGND VPWR VPWR picorv32_1031/HI eoi[28] sky130_fd_sc_hd__conb_1
Xpicorv32_1075 VGND VGND VPWR VPWR picorv32_1075/HI trace_data[3] sky130_fd_sc_hd__conb_1
Xpicorv32_1086 VGND VGND VPWR VPWR picorv32_1086/HI trace_data[14] sky130_fd_sc_hd__conb_1
Xpicorv32_1064 VGND VGND VPWR VPWR picorv32_1064/HI pcpi_insn[25] sky130_fd_sc_hd__conb_1
Xpicorv32_1053 VGND VGND VPWR VPWR picorv32_1053/HI pcpi_insn[14] sky130_fd_sc_hd__conb_1
XFILLER_21_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07499_ net1339 net494 net427 VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1097 VGND VGND VPWR VPWR picorv32_1097/HI trace_data[25] sky130_fd_sc_hd__conb_1
X_09238_ net1325 net320 net402 VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__mux2_1
XFILLER_119_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09169_ _04763_ _04781_ _04782_ _04783_ VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__or4b_1
XFILLER_5_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11200_ clknet_leaf_23_clk _01241_ VGND VGND VPWR VPWR cpuregs\[29\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_102_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11131_ clknet_leaf_26_clk _01172_ VGND VGND VPWR VPWR cpuregs\[31\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold991 cpuregs\[3\]\[21\] VGND VGND VPWR VPWR net2099 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_122_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold980 cpuregs\[22\]\[15\] VGND VGND VPWR VPWR net2088 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11062_ clknet_leaf_88_clk _01113_ VGND VGND VPWR VPWR mem_rdata_q\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_103_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10013_ clknet_leaf_140_clk _00137_ VGND VGND VPWR VPWR cpuregs\[30\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10915_ clknet_leaf_8_clk _00971_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dfxtp_1
XFILLER_60_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10846_ clknet_leaf_88_clk _00905_ VGND VGND VPWR VPWR decoded_imm_j\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10777_ clknet_leaf_61_clk alu_out\[24\] VGND VGND VPWR VPWR alu_out_q\[24\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_4_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_2210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_766 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_145_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_145_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_130_2410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_97_1884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11329_ clknet_leaf_33_clk _01370_ VGND VGND VPWR VPWR cpuregs\[5\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_122_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06870_ cpuregs\[28\]\[20\] cpuregs\[29\]\[20\] cpuregs\[30\]\[20\] cpuregs\[31\]\[20\]
+ net793 net756 VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__mux4_1
XFILLER_67_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05821_ _02072_ _02380_ net542 VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__a21o_1
XFILLER_39_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_128_2383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05752_ _02120_ _02195_ _02198_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__o21a_1
X_08540_ _04236_ _04237_ _00009_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_141_2583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08471_ net235 net96 VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__nand2b_2
X_05683_ _02129_ net578 VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__nor2_1
X_07422_ net1596 net254 net441 VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_141_2594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07353_ net1258 net263 net447 VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__mux2_1
X_07284_ net1810 net272 net456 VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__mux2_1
X_06304_ net851 _01608_ net606 _01604_ _02738_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__a221oi_4
X_09023_ net894 _04691_ net668 VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__a21o_1
X_06235_ _02676_ _02677_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__nor2_1
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold210 cpuregs\[24\]\[12\] VGND VGND VPWR VPWR net1318 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_116_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold243 cpuregs\[21\]\[13\] VGND VGND VPWR VPWR net1351 sky130_fd_sc_hd__dlygate4sd3_1
X_06166_ reg_pc\[10\] _02615_ reg_pc\[11\] VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__a21oi_1
Xhold232 cpuregs\[29\]\[3\] VGND VGND VPWR VPWR net1340 sky130_fd_sc_hd__dlygate4sd3_1
Xhold221 cpuregs\[17\]\[9\] VGND VGND VPWR VPWR net1329 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_148_2704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold276 cpuregs\[21\]\[15\] VGND VGND VPWR VPWR net1384 sky130_fd_sc_hd__dlygate4sd3_1
Xhold254 cpuregs\[31\]\[17\] VGND VGND VPWR VPWR net1362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold265 cpuregs\[14\]\[6\] VGND VGND VPWR VPWR net1373 sky130_fd_sc_hd__dlygate4sd3_1
X_06097_ cpuregs\[8\]\[4\] cpuregs\[9\]\[4\] cpuregs\[10\]\[4\] cpuregs\[11\]\[4\]
+ net953 net918 VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__mux4_1
Xhold287 cpuregs\[4\]\[8\] VGND VGND VPWR VPWR net1395 sky130_fd_sc_hd__dlygate4sd3_1
X_05117_ reg_pc\[5\] decoded_imm\[5\] VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__nand2_1
X_09925_ clknet_leaf_31_clk _00054_ VGND VGND VPWR VPWR cpuregs\[11\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_05048_ net8 _01656_ net130 net1 _01658_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__a221o_1
Xfanout701 net702 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__clkbuf_2
Xfanout712 net713 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__buf_2
Xhold298 cpuregs\[29\]\[8\] VGND VGND VPWR VPWR net1406 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout723 net725 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__buf_2
X_09856_ net265 net1861 net347 VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__mux2_1
Xfanout767 net771 VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__clkbuf_4
XFILLER_105_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout756 net757 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__clkbuf_2
Xfanout745 net748 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__clkbuf_2
Xfanout734 _00014_ VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__clkbuf_4
XFILLER_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08807_ net211 net632 _04487_ _04488_ VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__o22a_1
Xfanout778 net781 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__buf_4
Xfanout789 net790 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__buf_4
X_09787_ net275 net2049 net355 VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__mux2_1
X_06999_ _03408_ _03407_ VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__and2b_1
XFILLER_46_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_105 _02718_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08738_ cpuregs\[16\]\[14\] cpuregs\[17\]\[14\] cpuregs\[18\]\[14\] cpuregs\[19\]\[14\]
+ net958 net923 VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__mux4_1
X_08669_ cpuregs\[12\]\[10\] cpuregs\[13\]\[10\] cpuregs\[14\]\[10\] cpuregs\[15\]\[10\]
+ net951 net916 VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__mux4_1
XFILLER_60_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10700_ clknet_leaf_68_clk _00792_ VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_64_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_139_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10631_ clknet_leaf_85_clk _00755_ VGND VGND VPWR VPWR count_cycle\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10562_ clknet_leaf_134_clk _00686_ VGND VGND VPWR VPWR reg_next_pc\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_246 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10493_ clknet_leaf_108_clk _00617_ VGND VGND VPWR VPWR count_instr\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_135_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_150_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11114_ clknet_leaf_99_clk _00021_ VGND VGND VPWR VPWR cpu_state\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_339 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11045_ clknet_leaf_87_clk _01096_ VGND VGND VPWR VPWR mem_rdata_q\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_92_735 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_64_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10829_ clknet_leaf_99_clk _00888_ VGND VGND VPWR VPWR decoded_imm_j\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_15_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_145_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06020_ net194 _02512_ net636 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__mux2_1
XFILLER_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_141_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_114_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07971_ decoded_imm_j\[8\] _03704_ VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__nand2_1
X_06922_ cpuregs\[4\]\[22\] cpuregs\[5\]\[22\] cpuregs\[6\]\[22\] cpuregs\[7\]\[22\]
+ net798 net761 VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__mux4_1
X_09710_ net323 net1867 net361 VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__mux2_1
XFILLER_95_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_2623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_573 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06853_ net307 _03253_ _03268_ _03243_ VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__a31o_1
XFILLER_83_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_83_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09641_ net336 net1583 net369 VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__mux2_1
X_05804_ _02050_ _02365_ net542 VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__a21o_1
X_06784_ net870 net510 _03120_ net497 VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__o211a_1
X_09572_ net1972 _02601_ net377 VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__mux2_1
XFILLER_82_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05735_ _02139_ _02304_ net543 VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__a21o_1
XFILLER_24_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08523_ cpuregs\[0\]\[0\] cpuregs\[1\]\[0\] cpuregs\[2\]\[0\] cpuregs\[3\]\[0\] net950
+ net915 VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__mux4_1
XFILLER_63_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08454_ cpuregs\[24\]\[31\] cpuregs\[25\]\[31\] net795 VGND VGND VPWR VPWR _04188_
+ sky130_fd_sc_hd__mux2_1
X_05666_ instr_xor instr_xori VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_46_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05597_ net227 net852 VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__and2b_1
X_08385_ count_cycle\[46\] _04135_ net988 VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__o21ai_1
X_07405_ net1378 net325 net438 VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07336_ net1254 net339 net446 VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__mux2_1
X_09006_ decoded_imm\[28\] net599 net628 VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__a21o_1
X_07267_ net1441 net474 net454 VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__mux2_1
XFILLER_151_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06218_ reg_pc\[21\] reg_pc\[20\] _02656_ VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__and3_1
X_07198_ net1606 net527 net465 VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__mux2_1
XFILLER_132_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06149_ _02605_ _02608_ net565 VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__mux2_1
XFILLER_132_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout542 net543 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__clkbuf_4
XFILLER_99_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout520 _02718_ VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__buf_2
Xfanout531 _02588_ VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout575 _02483_ VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__clkbuf_4
Xfanout553 net555 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__buf_2
XFILLER_76_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09908_ clknet_leaf_137_clk _00037_ VGND VGND VPWR VPWR cpuregs\[11\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xfanout586 _02242_ VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__clkbuf_2
Xfanout597 _01652_ VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__buf_2
X_09839_ net340 net1957 net345 VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__mux2_1
XFILLER_132_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_132_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_153_Right_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10614_ clknet_leaf_87_clk _00738_ VGND VGND VPWR VPWR count_cycle\[31\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_12_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10545_ clknet_leaf_64_clk _00669_ VGND VGND VPWR VPWR reg_pc\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_130_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_130_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_94_1843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_94_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10476_ clknet_leaf_85_clk _00600_ VGND VGND VPWR VPWR count_instr\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_123_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11028_ clknet_leaf_39_clk _01084_ VGND VGND VPWR VPWR cpuregs\[19\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_92_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_125_2331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_92_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05520_ _02096_ _02099_ VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__nand2_1
XFILLER_33_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_1972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05451_ count_instr\[30\] net823 net623 _02032_ VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__a211o_1
XFILLER_60_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08170_ net812 _03721_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__xnor2_1
XANTENNA_27 _03573_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_103_1983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_38 _04879_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_16 _02718_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_31_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07121_ _03520_ _03521_ net655 VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__mux2_1
XFILLER_118_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05382_ count_instr\[57\] net817 net822 count_instr\[25\] VGND VGND VPWR VPWR _01969_
+ sky130_fd_sc_hd__a22o_1
XANTENNA_49 net119 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_121_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_121_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_118_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07052_ net860 net511 net490 _03459_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__o211a_1
Xoutput101 net101 VGND VGND VPWR VPWR mem_la_wdata[13] sky130_fd_sc_hd__buf_2
X_06003_ reg_out\[22\] reg_next_pc\[22\] net573 VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__mux2_1
Xoutput112 net112 VGND VGND VPWR VPWR mem_la_wdata[23] sky130_fd_sc_hd__buf_2
Xoutput134 net134 VGND VGND VPWR VPWR mem_valid sky130_fd_sc_hd__buf_2
Xoutput123 net123 VGND VGND VPWR VPWR mem_la_wdata[4] sky130_fd_sc_hd__buf_2
XFILLER_142_773 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput145 net145 VGND VGND VPWR VPWR mem_wdata[19] sky130_fd_sc_hd__buf_2
Xoutput156 net156 VGND VGND VPWR VPWR mem_wdata[29] sky130_fd_sc_hd__buf_2
Xoutput167 net167 VGND VGND VPWR VPWR mem_wstrb[0] sky130_fd_sc_hd__buf_2
Xoutput189 net189 VGND VGND VPWR VPWR pcpi_rs1[26] sky130_fd_sc_hd__buf_2
Xoutput178 net178 VGND VGND VPWR VPWR pcpi_rs1[16] sky130_fd_sc_hd__buf_2
XFILLER_114_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07954_ net688 reg_next_pc\[6\] net545 _03702_ VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__a22o_1
X_06905_ net735 _03313_ net728 VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__o21a_1
X_07885_ reg_pc\[24\] net505 _03721_ net605 VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__a22o_1
XFILLER_110_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_96_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09624_ net265 net2196 net376 VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__mux2_1
XFILLER_110_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06836_ net489 _03173_ _03251_ _03250_ VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__a31o_1
XFILLER_56_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09555_ net1591 net276 net382 VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__mux2_1
X_06767_ cpuregs\[24\]\[16\] cpuregs\[25\]\[16\] cpuregs\[26\]\[16\] cpuregs\[27\]\[16\]
+ net801 net762 VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__mux4_1
XFILLER_43_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09486_ net2169 net290 net391 VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__mux2_1
X_06698_ _03117_ _03118_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__nor2_1
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08506_ net631 _01641_ _02731_ net503 _01648_ VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__a221o_1
X_05718_ _02142_ _02290_ VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__xor2_1
X_05649_ net221 net856 VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__and2b_1
X_08437_ net190 _01625_ _02035_ net490 net514 VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_61_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08368_ _04125_ _04126_ VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__nor2_1
X_07319_ net1290 net266 net451 VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__mux2_1
X_08299_ count_cycle\[13\] _04080_ count_cycle\[14\] VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__a21o_1
XFILLER_20_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_112_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_112_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_125_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10330_ clknet_leaf_114_clk _00454_ VGND VGND VPWR VPWR cpuregs\[16\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_10261_ clknet_leaf_75_clk _00385_ VGND VGND VPWR VPWR cpuregs\[27\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_76_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10192_ clknet_leaf_51_clk _00316_ VGND VGND VPWR VPWR cpuregs\[9\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_79_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout350 _04878_ VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__buf_4
Xfanout383 net384 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__clkbuf_8
XFILLER_120_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_87_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout372 _04872_ VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__clkbuf_8
Xfanout361 net362 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkbuf_8
Xfanout394 net395 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkbuf_8
XFILLER_19_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_2050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_2250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput25 mem_rdata[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dlymetal6s2s_1
Xclkbuf_leaf_103_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_103_clk sky130_fd_sc_hd__clkbuf_8
Xinput14 mem_rdata[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_2
Xhold809 cpuregs\[23\]\[29\] VGND VGND VPWR VPWR net1917 sky130_fd_sc_hd__dlygate4sd3_1
X_10528_ clknet_leaf_133_clk _00652_ VGND VGND VPWR VPWR reg_pc\[8\] sky130_fd_sc_hd__dfxtp_2
XFILLER_7_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10459_ clknet_leaf_110_clk _00583_ VGND VGND VPWR VPWR count_instr\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04951_ instr_lbu instr_lb VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__or2_1
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_65_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07670_ count_instr\[2\] _03589_ count_instr\[3\] VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_36_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06621_ net875 net507 _02964_ net495 VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_36_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09340_ mem_rdata_q\[28\] net615 VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__and2_1
X_06552_ _02974_ _02975_ net731 VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__mux2_1
X_05503_ _02079_ _02081_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__or2_1
X_09271_ _04807_ net984 VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__and2b_1
XFILLER_33_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08222_ _04012_ _04017_ _04022_ VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__a21oi_1
X_06483_ _02876_ _02880_ _02881_ _02910_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_43_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_138_2544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05434_ _02014_ _02015_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__nand2_1
XFILLER_147_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08153_ _03958_ _03959_ _03960_ net837 VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__o22a_1
X_05365_ _01951_ _01952_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_151_2744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07104_ decoded_imm\[29\] net853 VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__nor2_1
X_08084_ decoded_imm_j\[15\] _03711_ _03881_ _03883_ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_151_2755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07035_ cpuregs\[20\]\[26\] cpuregs\[21\]\[26\] cpuregs\[22\]\[26\] cpuregs\[23\]\[26\]
+ net800 net763 VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__mux4_1
XFILLER_106_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05296_ _01889_ _01888_ _01884_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__or3b_1
XFILLER_115_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_102_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_88_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08986_ _04647_ _04648_ net683 VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__mux2_1
XFILLER_130_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07937_ _03700_ _03744_ _03701_ VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__a21oi_1
XFILLER_84_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07868_ reg_pc\[16\] net504 _03712_ net604 VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__a22o_1
XFILLER_56_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06819_ _03228_ _03229_ net651 VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__mux2_1
X_07799_ net2323 _03671_ net995 VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__o21ai_1
XFILLER_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09607_ net339 net1832 net373 VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__mux2_1
XFILLER_16_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09538_ net1681 net493 net384 VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__mux2_1
X_11500_ clknet_leaf_71_clk _01538_ VGND VGND VPWR VPWR cpuregs\[10\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_09469_ net1381 net536 net390 VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__mux2_1
XFILLER_132_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11431_ clknet_leaf_47_clk _01469_ VGND VGND VPWR VPWR cpuregs\[8\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11362_ clknet_leaf_32_clk _01400_ VGND VGND VPWR VPWR cpuregs\[6\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_153_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10313_ clknet_leaf_27_clk _00437_ VGND VGND VPWR VPWR cpuregs\[26\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11293_ clknet_leaf_54_clk _01334_ VGND VGND VPWR VPWR cpuregs\[4\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10244_ clknet_leaf_4_clk _00368_ VGND VGND VPWR VPWR cpuregs\[27\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10175_ clknet_leaf_149_clk _00299_ VGND VGND VPWR VPWR cpuregs\[9\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_2009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05150_ net711 _01746_ _01754_ VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__a21o_1
Xhold606 cpuregs\[17\]\[28\] VGND VGND VPWR VPWR net1714 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_133_2463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_2452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_116_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold617 cpuregs\[14\]\[4\] VGND VGND VPWR VPWR net1725 sky130_fd_sc_hd__dlygate4sd3_1
Xhold639 cpuregs\[11\]\[23\] VGND VGND VPWR VPWR net1747 sky130_fd_sc_hd__dlygate4sd3_1
Xhold628 cpuregs\[4\]\[15\] VGND VGND VPWR VPWR net1736 sky130_fd_sc_hd__dlygate4sd3_1
X_05081_ reg_pc\[3\] decoded_imm\[3\] VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__nand2_1
XFILLER_112_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08840_ net893 _04519_ _04518_ net480 VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__o211a_1
XFILLER_69_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08771_ decoded_imm\[15\] net598 net627 VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__a21o_1
X_05983_ reg_out\[12\] reg_next_pc\[12\] net571 VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__mux2_1
X_07722_ _03618_ _03622_ count_instr\[22\] VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__a21o_1
X_04934_ net233 VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__inv_2
X_07653_ net264 net1588 net413 VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__mux2_1
XFILLER_53_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06604_ cpuregs\[4\]\[10\] cpuregs\[5\]\[10\] cpuregs\[6\]\[10\] cpuregs\[7\]\[10\]
+ net779 net743 VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__mux4_1
XFILLER_25_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07584_ net1375 net273 net420 VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__mux2_1
XFILLER_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09323_ net496 net491 reg_sh\[0\] VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__mux2_1
XFILLER_41_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06535_ _02960_ _02961_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__nand2_1
X_09254_ net1800 net253 net405 VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__mux2_1
X_06466_ cpuregs\[24\]\[5\] cpuregs\[25\]\[5\] cpuregs\[26\]\[5\] cpuregs\[27\]\[5\]
+ net777 net741 VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__mux4_1
X_08205_ net690 reg_next_pc\[26\] net547 _03723_ VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__a22o_1
X_05417_ reg_pc\[27\] decoded_imm\[27\] _01997_ _01999_ _02000_ VGND VGND VPWR VPWR
+ _02001_ sky130_fd_sc_hd__a2111o_1
X_09185_ decoded_imm_j\[5\] _01119_ net331 VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__mux2_1
XFILLER_153_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08136_ net813 _03717_ _03919_ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__o21a_1
X_06397_ net649 _02828_ net723 VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__a21o_1
XFILLER_119_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05348_ reg_pc\[23\] decoded_imm\[23\] VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__nand2_1
XFILLER_107_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_150_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05279_ _01860_ _01862_ _01872_ VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__a21o_1
X_08067_ decoded_imm_j\[16\] _03712_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_56_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07018_ net857 _03427_ net307 VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__mux2_1
XFILLER_68_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_102_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08969_ net894 _04641_ net667 VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__a21o_1
X_10931_ clknet_leaf_32_clk _00987_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dfxtp_1
XFILLER_90_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10862_ clknet_leaf_138_clk _00918_ VGND VGND VPWR VPWR cpuregs\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10793_ clknet_leaf_96_clk _00852_ VGND VGND VPWR VPWR instr_bgeu sky130_fd_sc_hd__dfxtp_1
XFILLER_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_149_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_144_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11414_ clknet_leaf_142_clk _01452_ VGND VGND VPWR VPWR cpuregs\[8\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_138_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_2171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11345_ clknet_leaf_121_clk _01383_ VGND VGND VPWR VPWR cpuregs\[6\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11276_ clknet_leaf_23_clk _01317_ VGND VGND VPWR VPWR cpuregs\[22\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10227_ clknet_leaf_69_clk _00351_ VGND VGND VPWR VPWR cpuregs\[14\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10158_ clknet_leaf_43_clk _00282_ VGND VGND VPWR VPWR cpuregs\[21\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold3 cpuregs\[0\]\[3\] VGND VGND VPWR VPWR net1111 sky130_fd_sc_hd__dlygate4sd3_1
X_10089_ clknet_leaf_30_clk _00213_ VGND VGND VPWR VPWR cpuregs\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_66_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_844 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06320_ cpuregs\[4\]\[1\] cpuregs\[5\]\[1\] net788 VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__mux2_1
XFILLER_31_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_148_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06251_ _02689_ _02690_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__nor2_1
XFILLER_31_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
X_05202_ _01756_ _01769_ VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__nand2b_1
XFILLER_144_621 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06182_ reg_out\[14\] alu_out_q\[14\] net842 VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__mux2_1
XFILLER_132_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold414 cpuregs\[23\]\[14\] VGND VGND VPWR VPWR net1522 sky130_fd_sc_hd__dlygate4sd3_1
Xhold425 cpuregs\[27\]\[10\] VGND VGND VPWR VPWR net1533 sky130_fd_sc_hd__dlygate4sd3_1
Xhold436 cpuregs\[29\]\[6\] VGND VGND VPWR VPWR net1544 sky130_fd_sc_hd__dlygate4sd3_1
Xhold403 cpuregs\[21\]\[5\] VGND VGND VPWR VPWR net1511 sky130_fd_sc_hd__dlygate4sd3_1
X_05133_ count_cycle\[6\] net617 net589 _01738_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__o211a_1
Xhold447 cpuregs\[4\]\[25\] VGND VGND VPWR VPWR net1555 sky130_fd_sc_hd__dlygate4sd3_1
Xhold469 cpuregs\[25\]\[17\] VGND VGND VPWR VPWR net1577 sky130_fd_sc_hd__dlygate4sd3_1
Xhold458 cpuregs\[10\]\[9\] VGND VGND VPWR VPWR net1566 sky130_fd_sc_hd__dlygate4sd3_1
X_09941_ clknet_leaf_111_clk _00028_ VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__dfxtp_4
X_05064_ net182 net707 _01669_ net700 _01672_ VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__a221o_1
XFILLER_132_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout905 _00009_ VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__clkbuf_4
Xfanout916 net917 VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__clkbuf_2
Xfanout938 net940 VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__clkbuf_2
Xfanout927 net933 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__clkbuf_2
Xfanout949 net952 VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__buf_2
X_09872_ decoded_imm_j\[11\] _01114_ net331 VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_5_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1114 cpuregs\[3\]\[22\] VGND VGND VPWR VPWR net2222 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_140_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08823_ net893 _04502_ net666 VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__a21o_1
Xhold1103 instr_slt VGND VGND VPWR VPWR net2211 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_51_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_146_2665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1136 count_cycle\[24\] VGND VGND VPWR VPWR net2244 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1125 count_instr\[20\] VGND VGND VPWR VPWR net2233 sky130_fd_sc_hd__dlygate4sd3_1
X_08754_ cpuregs\[20\]\[15\] cpuregs\[21\]\[15\] cpuregs\[22\]\[15\] cpuregs\[23\]\[15\]
+ net961 net926 VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__mux4_1
Xhold1158 count_cycle\[46\] VGND VGND VPWR VPWR net2266 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1147 _00842_ VGND VGND VPWR VPWR net2255 sky130_fd_sc_hd__dlygate4sd3_1
X_05966_ net196 _02485_ net634 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__mux2_1
X_07705_ count_instr\[16\] count_instr\[15\] count_instr\[14\] _03608_ VGND VGND VPWR
+ VPWR _03613_ sky130_fd_sc_hd__and4_1
XFILLER_66_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04917_ net851 VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__inv_2
Xhold1169 count_cycle\[7\] VGND VGND VPWR VPWR net2277 sky130_fd_sc_hd__dlygate4sd3_1
X_05897_ _02101_ _02105_ _02448_ _02103_ VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__o31a_1
Xclkbuf_leaf_92_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_92_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_26_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08685_ net899 _04372_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__or2_1
XFILLER_54_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07636_ net339 net1434 net410 VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07567_ net1343 net475 net418 VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1010 VGND VGND VPWR VPWR picorv32_1010/HI eoi[7] sky130_fd_sc_hd__conb_1
Xpicorv32_1043 VGND VGND VPWR VPWR picorv32_1043/HI pcpi_insn[4] sky130_fd_sc_hd__conb_1
XFILLER_110_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09306_ net1154 net121 net484 VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1032 VGND VGND VPWR VPWR picorv32_1032/HI eoi[29] sky130_fd_sc_hd__conb_1
Xpicorv32_1021 VGND VGND VPWR VPWR picorv32_1021/HI eoi[18] sky130_fd_sc_hd__conb_1
X_06518_ cpuregs\[24\]\[7\] cpuregs\[25\]\[7\] cpuregs\[26\]\[7\] cpuregs\[27\]\[7\]
+ net775 net739 VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__mux4_1
Xpicorv32_1054 VGND VGND VPWR VPWR picorv32_1054/HI pcpi_insn[15] sky130_fd_sc_hd__conb_1
Xpicorv32_1065 VGND VGND VPWR VPWR picorv32_1065/HI pcpi_insn[26] sky130_fd_sc_hd__conb_1
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09237_ net1454 net323 net402 VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__mux2_1
X_07498_ net1420 net527 net427 VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1076 VGND VGND VPWR VPWR picorv32_1076/HI trace_data[4] sky130_fd_sc_hd__conb_1
Xpicorv32_1098 VGND VGND VPWR VPWR picorv32_1098/HI trace_data[26] sky130_fd_sc_hd__conb_1
Xpicorv32_1087 VGND VGND VPWR VPWR picorv32_1087/HI trace_data[15] sky130_fd_sc_hd__conb_1
X_06449_ _02866_ _02868_ _02878_ VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__and3_1
XFILLER_108_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09168_ mem_rdata_q\[3\] mem_rdata_q\[4\] mem_rdata_q\[5\] mem_rdata_q\[6\] VGND
+ VGND VPWR VPWR _04783_ sky130_fd_sc_hd__and4b_1
X_08119_ _03926_ _03929_ net557 VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__a21oi_1
X_09099_ net1184 net501 _04749_ _04750_ VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__a22o_1
XFILLER_135_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11130_ clknet_leaf_11_clk _01171_ VGND VGND VPWR VPWR cpuregs\[31\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold981 cpuregs\[6\]\[13\] VGND VGND VPWR VPWR net2089 sky130_fd_sc_hd__dlygate4sd3_1
Xhold970 is_jalr_addi_slti_sltiu_xori_ori_andi VGND VGND VPWR VPWR net2078 sky130_fd_sc_hd__dlygate4sd3_1
X_11061_ clknet_leaf_92_clk _01112_ VGND VGND VPWR VPWR mem_rdata_q\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold992 cpuregs\[10\]\[11\] VGND VGND VPWR VPWR net2100 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_130_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_110_2090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10012_ clknet_leaf_126_clk _00136_ VGND VGND VPWR VPWR cpuregs\[30\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_91_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_83_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_83_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_45_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10914_ clknet_leaf_29_clk _00970_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dfxtp_1
X_10845_ clknet_leaf_92_clk _00904_ VGND VGND VPWR VPWR decoded_imm_j\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_71_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_117_2200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10776_ clknet_leaf_57_clk alu_out\[23\] VGND VGND VPWR VPWR alu_out_q\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_130_2411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_99_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11328_ clknet_leaf_26_clk _01369_ VGND VGND VPWR VPWR cpuregs\[5\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_10_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11259_ clknet_leaf_9_clk _01300_ VGND VGND VPWR VPWR cpuregs\[22\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_105_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05820_ _02072_ _02380_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__nor2_1
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_128_2384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_74_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_74_clk sky130_fd_sc_hd__clkbuf_8
X_05751_ _02120_ net577 _02318_ _02319_ VGND VGND VPWR VPWR alu_out\[11\] sky130_fd_sc_hd__a211o_1
XFILLER_35_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08470_ net235 net129 VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__and2b_1
X_05682_ _02129_ _02258_ _02259_ net544 VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__o211a_1
XFILLER_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07421_ net1982 net257 net440 VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_141_2595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07352_ net1464 net267 net448 VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_114_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06303_ _01628_ _02732_ _02737_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__or3b_2
XFILLER_50_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07283_ net1394 net275 net456 VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__mux2_1
X_09022_ net905 _04687_ _04686_ net663 VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__o211a_1
XFILLER_117_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06234_ reg_pc\[24\] reg_pc\[23\] _02669_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__and3_1
XFILLER_40_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold200 cpuregs\[15\]\[22\] VGND VGND VPWR VPWR net1308 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_129_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold211 cpuregs\[14\]\[17\] VGND VGND VPWR VPWR net1319 sky130_fd_sc_hd__dlygate4sd3_1
X_06165_ reg_out\[11\] alu_out_q\[11\] net841 VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__mux2_1
Xhold222 cpuregs\[21\]\[14\] VGND VGND VPWR VPWR net1330 sky130_fd_sc_hd__dlygate4sd3_1
Xhold233 cpuregs\[15\]\[8\] VGND VGND VPWR VPWR net1341 sky130_fd_sc_hd__dlygate4sd3_1
Xhold244 cpuregs\[14\]\[8\] VGND VGND VPWR VPWR net1352 sky130_fd_sc_hd__dlygate4sd3_1
X_05116_ reg_pc\[5\] decoded_imm\[5\] VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__or2_1
XFILLER_116_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold255 cpuregs\[15\]\[17\] VGND VGND VPWR VPWR net1363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold266 cpuregs\[4\]\[1\] VGND VGND VPWR VPWR net1374 sky130_fd_sc_hd__dlygate4sd3_1
X_06096_ cpuregs\[12\]\[4\] cpuregs\[13\]\[4\] cpuregs\[14\]\[4\] cpuregs\[15\]\[4\]
+ net953 net918 VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__mux4_1
Xhold277 cpuregs\[15\]\[1\] VGND VGND VPWR VPWR net1385 sky130_fd_sc_hd__dlygate4sd3_1
Xhold288 cpuregs\[15\]\[29\] VGND VGND VPWR VPWR net1396 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_148_2705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_123_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09924_ clknet_leaf_54_clk _00053_ VGND VGND VPWR VPWR cpuregs\[11\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xfanout724 net725 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__buf_4
X_05047_ net884 net887 _01654_ net593 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__a2bb2o_4
Xfanout702 cpu_state\[6\] VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__clkbuf_4
Xfanout713 net716 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlymetal6s2s_1
Xhold299 cpuregs\[31\]\[5\] VGND VGND VPWR VPWR net1407 sky130_fd_sc_hd__dlygate4sd3_1
X_09855_ net269 net1767 net347 VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__mux2_1
XFILLER_105_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout735 net736 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__buf_4
Xfanout757 net765 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__clkbuf_2
Xfanout746 net748 VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__clkbuf_4
Xfanout768 net771 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__clkbuf_4
XFILLER_112_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_86_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08806_ decoded_imm\[17\] net598 net627 VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__a21o_1
Xfanout779 net781 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__clkbuf_2
X_09786_ net279 net2006 net355 VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__mux2_1
XFILLER_100_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06998_ _03380_ _03383_ _03406_ net610 VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__a31o_1
XFILLER_39_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_65_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_65_clk sky130_fd_sc_hd__clkbuf_8
X_05949_ net122 net213 net594 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__mux2_2
XFILLER_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08737_ cpuregs\[20\]\[14\] cpuregs\[21\]\[14\] cpuregs\[22\]\[14\] cpuregs\[23\]\[14\]
+ net948 net913 VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_68_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_106 net491 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_27_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08668_ cpuregs\[0\]\[10\] cpuregs\[1\]\[10\] cpuregs\[2\]\[10\] cpuregs\[3\]\[10\]
+ net948 net913 VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__mux4_1
XFILLER_27_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07619_ net1640 net267 net415 VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__mux2_1
XFILLER_121_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_132_Left_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10630_ clknet_leaf_105_clk _00754_ VGND VGND VPWR VPWR count_cycle\[47\] sky130_fd_sc_hd__dfxtp_1
X_08599_ _04282_ _04283_ net674 VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__mux2_1
XFILLER_14_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10561_ clknet_leaf_133_clk _00685_ VGND VGND VPWR VPWR reg_next_pc\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_14_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10492_ clknet_leaf_108_clk _00616_ VGND VGND VPWR VPWR count_instr\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_112_2130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_258 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_141_Left_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_146_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11113_ clknet_leaf_98_clk _00020_ VGND VGND VPWR VPWR cpu_state\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_104_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11044_ clknet_leaf_87_clk _01095_ VGND VGND VPWR VPWR mem_rdata_q\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_65_906 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_56_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_56_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_123_2292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10828_ clknet_leaf_131_clk _00887_ VGND VGND VPWR VPWR decoded_imm_j\[5\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_15_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10759_ clknet_leaf_141_clk alu_out\[6\] VGND VGND VPWR VPWR alu_out_q\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07970_ _03704_ _03786_ net687 VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__o21ai_1
XFILLER_101_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06921_ net862 net509 _03251_ net498 VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__o211a_1
XFILLER_95_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_143_2624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_95_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06852_ reg_pc\[19\] net561 _03267_ net521 VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__a211o_1
XFILLER_67_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09640_ net339 net2134 net369 VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__mux2_1
XFILLER_95_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05803_ _02050_ _02365_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__nor2_1
XFILLER_83_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06783_ net175 net510 net489 _03200_ VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__o211a_1
XFILLER_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09571_ net1229 _02596_ net380 VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__mux2_1
XFILLER_27_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_47_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_47_clk sky130_fd_sc_hd__clkbuf_8
X_05734_ _02139_ _02304_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__nor2_1
X_08522_ cpuregs\[4\]\[0\] cpuregs\[5\]\[0\] cpuregs\[6\]\[0\] cpuregs\[7\]\[0\] net950
+ net915 VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__mux4_1
X_08453_ net736 _04186_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__and2_1
XFILLER_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05665_ instr_xor instr_xori VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__nor2_2
X_07404_ net1278 net327 net438 VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__mux2_1
XFILLER_24_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08384_ _04135_ _04136_ VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__nor2_1
X_05596_ _02116_ _02173_ _02174_ _02175_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__and4bb_1
XFILLER_51_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07335_ net1569 net470 net446 VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__mux2_1
XFILLER_137_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07266_ net1412 net492 net455 VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__mux2_1
X_09005_ _00011_ _04672_ _04675_ net481 VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__o211a_1
X_06217_ reg_pc\[20\] _02656_ reg_pc\[21\] VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__a21oi_1
XFILLER_105_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07197_ net1397 net532 net465 VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__mux2_1
XFILLER_144_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_132_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06148_ _02606_ _02607_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__nor2_1
X_06079_ cpuregs\[20\]\[3\] cpuregs\[21\]\[3\] cpuregs\[22\]\[3\] cpuregs\[23\]\[3\]
+ net955 net920 VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__mux4_1
X_09907_ net1149 VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__clkbuf_1
Xfanout521 net522 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__buf_2
Xfanout510 _02736_ VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__buf_2
Xfanout532 net533 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__clkbuf_2
Xfanout554 net555 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__clkbuf_2
Xfanout543 _02248_ VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__buf_4
Xfanout565 net566 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout576 net577 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__clkbuf_4
Xfanout587 _01844_ VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__buf_2
Xfanout598 net599 VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__clkbuf_4
XFILLER_74_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09838_ net472 net1680 net345 VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__mux2_1
X_09769_ net527 net1797 net354 VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__mux2_1
XFILLER_132_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_38_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_38_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10613_ clknet_leaf_89_clk _00737_ VGND VGND VPWR VPWR count_cycle\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_12_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10544_ clknet_leaf_65_clk _00668_ VGND VGND VPWR VPWR reg_pc\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10475_ clknet_leaf_85_clk _00599_ VGND VGND VPWR VPWR count_instr\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11027_ clknet_leaf_36_clk _01083_ VGND VGND VPWR VPWR cpuregs\[19\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_65_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_125_2332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_65_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_29_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_103_1973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05450_ count_instr\[62\] net816 net825 count_cycle\[62\] VGND VGND VPWR VPWR _02032_
+ sky130_fd_sc_hd__a22o_1
XFILLER_33_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_39 _04879_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_103_1984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_17 _02722_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05381_ net18 net597 net587 VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__a21o_1
XANTENNA_28 _03574_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_21_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07120_ _03524_ _03525_ net655 VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__mux2_1
XFILLER_119_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07051_ net852 net514 VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__or2_1
X_06002_ net863 _02503_ net637 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__mux2_1
XFILLER_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput113 net113 VGND VGND VPWR VPWR mem_la_wdata[24] sky130_fd_sc_hd__buf_2
Xoutput102 net102 VGND VGND VPWR VPWR mem_la_wdata[14] sky130_fd_sc_hd__buf_2
Xoutput124 net845 VGND VGND VPWR VPWR mem_la_wdata[5] sky130_fd_sc_hd__buf_2
Xoutput168 net168 VGND VGND VPWR VPWR mem_wstrb[1] sky130_fd_sc_hd__buf_2
Xoutput157 net157 VGND VGND VPWR VPWR mem_wdata[2] sky130_fd_sc_hd__buf_2
Xoutput146 net146 VGND VGND VPWR VPWR mem_wdata[1] sky130_fd_sc_hd__buf_2
Xoutput135 net135 VGND VGND VPWR VPWR mem_wdata[0] sky130_fd_sc_hd__buf_2
Xoutput179 net869 VGND VGND VPWR VPWR pcpi_rs1[17] sky130_fd_sc_hd__buf_2
XFILLER_142_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07953_ net558 _03776_ VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__nor2_1
X_06904_ _03309_ _03310_ _03314_ _03315_ net653 net642 VGND VGND VPWR VPWR _03318_
+ sky130_fd_sc_hd__mux4_1
X_07884_ _02675_ reg_next_pc\[24\] net573 VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__mux2_2
X_09623_ net268 net2002 net375 VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__mux2_1
X_06835_ net859 net513 VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__or2_1
XFILLER_95_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06766_ cpuregs\[28\]\[16\] cpuregs\[29\]\[16\] cpuregs\[30\]\[16\] cpuregs\[31\]\[16\]
+ net799 net762 VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__mux4_1
X_09554_ net1469 net280 net382 VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__mux2_1
XFILLER_83_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09485_ net1962 net294 net391 VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__mux2_1
X_06697_ _03090_ _03094_ _03116_ net609 VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__a31o_1
XFILLER_70_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08505_ net978 _01601_ _04207_ VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__and3_1
X_05717_ _02192_ _02289_ net692 VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__mux2_1
X_05648_ net222 net855 VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__and2b_1
X_08436_ _03533_ _03538_ _04168_ net610 VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_61_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08367_ net2271 _04124_ net981 VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__o21ai_1
X_07318_ net1894 net269 net452 VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__mux2_1
XFILLER_109_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05579_ _02157_ _02158_ VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__nor2_1
XFILLER_20_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08298_ net2273 _04080_ _04082_ VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__a21oi_1
X_07249_ net1795 net281 net460 VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__mux2_1
X_10260_ clknet_leaf_76_clk _00384_ VGND VGND VPWR VPWR cpuregs\[27\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10191_ clknet_leaf_47_clk _00315_ VGND VGND VPWR VPWR cpuregs\[9\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_133_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_87_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout340 net342 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkbuf_2
Xfanout351 _04878_ VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_8
Xfanout362 _04875_ VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__buf_4
Xfanout384 _04869_ VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__clkbuf_8
Xfanout373 net374 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_8
Xfanout395 net396 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__buf_4
XFILLER_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_2051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_120_2251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput26 mem_rdata[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
XFILLER_7_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput15 mem_rdata[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_2
XFILLER_143_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_760 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10527_ clknet_leaf_132_clk _00651_ VGND VGND VPWR VPWR reg_pc\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_143_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10458_ clknet_leaf_110_clk _00582_ VGND VGND VPWR VPWR count_instr\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10389_ clknet_leaf_75_clk _00513_ VGND VGND VPWR VPWR cpuregs\[25\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_111_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04950_ instr_auipc instr_lui VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__or2_1
XFILLER_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06620_ _03040_ _03041_ _03042_ net609 VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__a31oi_1
XFILLER_93_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06551_ _02969_ _02970_ _02976_ _02977_ net644 net641 VGND VGND VPWR VPWR _02978_
+ sky130_fd_sc_hd__mux4_1
X_05502_ _02079_ _02081_ VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__nor2_1
X_09270_ mem_do_wdata _01572_ _04809_ VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__o21ai_1
X_06482_ _02876_ _02880_ _02881_ _02910_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__a31o_1
X_08221_ _04022_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__inv_2
X_05433_ _02014_ _02015_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__or2_1
XFILLER_61_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_147_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08152_ _03719_ _03941_ VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__xor2_1
X_05364_ reg_pc\[24\] decoded_imm\[24\] VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__nand2_1
XFILLER_20_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_151_2745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07103_ net307 _03495_ _03509_ _03480_ VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__a31o_1
X_05295_ net704 net344 _01885_ net709 net180 VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__a32o_1
X_08083_ _03894_ _03895_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__nand2_1
Xclkbuf_leaf_9_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
X_07034_ cpuregs\[0\]\[26\] cpuregs\[1\]\[26\] cpuregs\[2\]\[26\] cpuregs\[3\]\[26\]
+ net800 net763 VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_58_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08985_ _04653_ _04655_ _04656_ net894 net898 VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__a221o_1
XFILLER_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07936_ _03748_ _03759_ _03758_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__a21oi_1
XFILLER_69_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07867_ _02643_ reg_next_pc\[16\] net572 VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__mux2_1
XFILLER_83_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06818_ cpuregs\[24\]\[18\] cpuregs\[25\]\[18\] cpuregs\[26\]\[18\] cpuregs\[27\]\[18\]
+ net793 net756 VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__mux4_1
XFILLER_83_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07798_ count_instr\[50\] count_instr\[49\] count_instr\[48\] _03667_ VGND VGND VPWR
+ VPWR _03672_ sky130_fd_sc_hd__and4_1
X_09606_ net471 net1706 net373 VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__mux2_1
X_06749_ decoded_imm\[16\] net870 VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__nand2_1
X_09537_ net2000 net528 net384 VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__mux2_1
XFILLER_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09468_ net1532 net540 net389 VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__mux2_1
X_08419_ net2313 _04157_ _04158_ VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__a21oi_1
X_09399_ net835 decoded_imm_j\[1\] _04825_ mem_rdata_q\[8\] net551 VGND VGND VPWR
+ VPWR _04864_ sky130_fd_sc_hd__a221o_1
X_11430_ clknet_leaf_41_clk _01468_ VGND VGND VPWR VPWR cpuregs\[8\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_22_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11361_ clknet_leaf_29_clk _01399_ VGND VGND VPWR VPWR cpuregs\[6\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10312_ clknet_leaf_54_clk _00436_ VGND VGND VPWR VPWR cpuregs\[26\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_138_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11292_ clknet_leaf_16_clk _01333_ VGND VGND VPWR VPWR cpuregs\[4\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10243_ clknet_leaf_4_clk _00367_ VGND VGND VPWR VPWR cpuregs\[27\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_10174_ clknet_leaf_142_clk _00298_ VGND VGND VPWR VPWR cpuregs\[9\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold607 cpuregs\[17\]\[29\] VGND VGND VPWR VPWR net1715 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_133_2453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold618 cpuregs\[11\]\[11\] VGND VGND VPWR VPWR net1726 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold629 cpuregs\[17\]\[25\] VGND VGND VPWR VPWR net1737 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_133_2464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05080_ _01673_ _01680_ _01679_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__o21ai_1
XFILLER_97_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08770_ _04451_ _04453_ net482 _04450_ VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__o211a_1
X_05982_ net173 _02493_ net635 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__mux2_2
XFILLER_38_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07721_ net997 _03621_ _03623_ VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__and3_1
XFILLER_38_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04933_ net122 VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__inv_2
X_07652_ net267 net1653 net413 VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07583_ net1360 net278 net420 VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__mux2_1
XFILLER_53_547 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06603_ cpuregs\[20\]\[10\] cpuregs\[21\]\[10\] cpuregs\[22\]\[10\] cpuregs\[23\]\[10\]
+ net778 net742 VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__mux4_1
XFILLER_80_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09322_ latched_rd\[4\] _04818_ _04819_ net1276 VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__a22o_1
XFILLER_41_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06534_ _02909_ _02911_ _02935_ _02934_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__a31o_1
X_09253_ net1353 net257 net404 VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__mux2_1
X_06465_ _02888_ _02890_ _02892_ _02894_ net726 VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__a221o_1
X_08204_ net557 _04007_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__nor2_1
X_05416_ reg_pc\[26\] decoded_imm\[26\] _01985_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__and3_1
X_09184_ mem_rdata_q\[25\] net18 net611 VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__mux2_1
X_06396_ cpuregs\[0\]\[3\] cpuregs\[1\]\[3\] cpuregs\[2\]\[3\] cpuregs\[3\]\[3\] net786
+ net750 VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__mux4_1
X_05347_ reg_pc\[23\] decoded_imm\[23\] VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__or2_1
X_08135_ _03921_ _03932_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__and2_1
XFILLER_119_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05278_ _01860_ _01862_ _01872_ VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__nand3_1
X_08066_ net991 _03880_ VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_73_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07017_ net525 _03409_ _03410_ _03412_ _03426_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__o41a_1
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08968_ _04627_ _04628_ net904 VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__mux2_1
X_08899_ cpuregs\[16\]\[23\] cpuregs\[17\]\[23\] cpuregs\[18\]\[23\] cpuregs\[19\]\[23\]
+ net966 net931 VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__mux4_1
XFILLER_84_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07919_ net834 _03744_ _03745_ _03742_ net848 VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__o221a_1
X_10930_ clknet_leaf_30_clk _00986_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dfxtp_1
XFILLER_57_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10861_ clknet_leaf_103_clk _00917_ VGND VGND VPWR VPWR is_beq_bne_blt_bge_bltu_bgeu
+ sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_27_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10792_ clknet_leaf_96_clk _00851_ VGND VGND VPWR VPWR instr_bltu sky130_fd_sc_hd__dfxtp_1
XFILLER_25_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_720 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11413_ clknet_leaf_140_clk _01451_ VGND VGND VPWR VPWR cpuregs\[8\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_115_2172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11344_ clknet_leaf_14_clk _01382_ VGND VGND VPWR VPWR cpuregs\[6\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11275_ clknet_leaf_63_clk _01316_ VGND VGND VPWR VPWR cpuregs\[22\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_10226_ clknet_leaf_49_clk _00350_ VGND VGND VPWR VPWR cpuregs\[14\]\[26\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_148_Right_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_18_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10157_ clknet_leaf_36_clk _00281_ VGND VGND VPWR VPWR cpuregs\[21\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xhold4 cpuregs\[0\]\[19\] VGND VGND VPWR VPWR net1112 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_58_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10088_ clknet_leaf_55_clk _00212_ VGND VGND VPWR VPWR cpuregs\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_94_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_856 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_90_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_27_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06250_ reg_pc\[27\] reg_pc\[26\] _02682_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__and3_1
XFILLER_31_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05201_ _01742_ net334 _01757_ _01800_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__o211ai_1
XFILLER_30_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06181_ net314 net1985 net477 VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__mux2_1
XFILLER_144_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold404 cpuregs\[20\]\[31\] VGND VGND VPWR VPWR net1512 sky130_fd_sc_hd__dlygate4sd3_1
X_05132_ count_instr\[6\] net819 net622 _01737_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__a211o_1
Xhold426 cpuregs\[20\]\[3\] VGND VGND VPWR VPWR net1534 sky130_fd_sc_hd__dlygate4sd3_1
Xhold415 cpuregs\[23\]\[1\] VGND VGND VPWR VPWR net1523 sky130_fd_sc_hd__dlygate4sd3_1
Xhold437 cpuregs\[31\]\[12\] VGND VGND VPWR VPWR net1545 sky130_fd_sc_hd__dlygate4sd3_1
X_09940_ clknet_leaf_99_clk _00027_ VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__dfxtp_4
Xhold448 cpuregs\[11\]\[2\] VGND VGND VPWR VPWR net1556 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_36_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold459 cpuregs\[4\]\[11\] VGND VGND VPWR VPWR net1567 sky130_fd_sc_hd__dlygate4sd3_1
X_05063_ reg_pc\[1\] decoded_imm\[1\] VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout906 net907 VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__clkbuf_4
XFILLER_140_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout939 net940 VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__clkbuf_4
Xfanout928 net929 VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__clkbuf_4
X_09871_ decoded_imm_j\[18\] _01112_ net333 VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_5_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout917 _00008_ VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__buf_2
Xhold1104 cpuregs\[8\]\[28\] VGND VGND VPWR VPWR net2212 sky130_fd_sc_hd__dlygate4sd3_1
X_08822_ net677 _04496_ _04495_ net662 VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__o211a_1
Xhold1115 cpuregs\[22\]\[31\] VGND VGND VPWR VPWR net2223 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_51_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1126 cpuregs\[8\]\[22\] VGND VGND VPWR VPWR net2234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1137 count_cycle\[60\] VGND VGND VPWR VPWR net2245 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1148 count_instr\[17\] VGND VGND VPWR VPWR net2256 sky130_fd_sc_hd__dlygate4sd3_1
X_08753_ net208 net630 _04436_ _04437_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__o22a_1
XFILLER_57_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05965_ reg_out\[3\] reg_next_pc\[3\] net570 VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__mux2_1
XFILLER_38_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07704_ _03612_ net995 _03611_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__and3b_1
X_04916_ latched_is_lb VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__inv_2
Xhold1159 count_cycle\[37\] VGND VGND VPWR VPWR net2267 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_39_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05896_ _02107_ _02435_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__nor2_1
XFILLER_81_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08684_ cpuregs\[24\]\[11\] cpuregs\[25\]\[11\] cpuregs\[26\]\[11\] cpuregs\[27\]\[11\]
+ net947 net912 VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__mux4_1
XFILLER_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07635_ net472 net1932 net410 VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__mux2_1
XFILLER_81_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07566_ net1221 net494 net419 VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1011 VGND VGND VPWR VPWR picorv32_1011/HI eoi[8] sky130_fd_sc_hd__conb_1
X_09305_ net1155 net120 net485 VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06517_ cpuregs\[28\]\[7\] cpuregs\[29\]\[7\] cpuregs\[30\]\[7\] cpuregs\[31\]\[7\]
+ net775 net739 VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__mux4_1
Xpicorv32_1033 VGND VGND VPWR VPWR picorv32_1033/HI eoi[30] sky130_fd_sc_hd__conb_1
Xpicorv32_1022 VGND VGND VPWR VPWR picorv32_1022/HI eoi[19] sky130_fd_sc_hd__conb_1
Xpicorv32_1077 VGND VGND VPWR VPWR picorv32_1077/HI trace_data[5] sky130_fd_sc_hd__conb_1
Xpicorv32_1055 VGND VGND VPWR VPWR picorv32_1055/HI pcpi_insn[16] sky130_fd_sc_hd__conb_1
Xpicorv32_1044 VGND VGND VPWR VPWR picorv32_1044/HI pcpi_insn[5] sky130_fd_sc_hd__conb_1
X_09236_ net1772 net326 net402 VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__mux2_1
XFILLER_22_775 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07497_ net1492 net533 net427 VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1066 VGND VGND VPWR VPWR picorv32_1066/HI pcpi_insn[27] sky130_fd_sc_hd__conb_1
Xpicorv32_1099 VGND VGND VPWR VPWR picorv32_1099/HI trace_data[27] sky130_fd_sc_hd__conb_1
Xpicorv32_1088 VGND VGND VPWR VPWR picorv32_1088/HI trace_data[16] sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06448_ _02876_ _02877_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__nand2_1
XFILLER_119_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09167_ mem_rdata_q\[19\] mem_rdata_q\[18\] mem_rdata_q\[0\] mem_rdata_q\[1\] VGND
+ VGND VPWR VPWR _04782_ sky130_fd_sc_hd__or4bb_1
X_06379_ net705 net879 net508 net496 VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__a31o_1
XFILLER_134_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_108_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08118_ net836 _03927_ _03928_ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__or3_1
X_09098_ net810 net976 net555 VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__and3_2
XFILLER_135_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08049_ _03708_ _03709_ _03832_ _03710_ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__a31o_1
Xhold982 cpuregs\[12\]\[28\] VGND VGND VPWR VPWR net2090 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_123_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold971 cpuregs\[6\]\[20\] VGND VGND VPWR VPWR net2079 sky130_fd_sc_hd__dlygate4sd3_1
X_11060_ clknet_leaf_92_clk _01111_ VGND VGND VPWR VPWR mem_rdata_q\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_1_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold960 cpuregs\[5\]\[4\] VGND VGND VPWR VPWR net2068 sky130_fd_sc_hd__dlygate4sd3_1
Xhold993 cpuregs\[6\]\[27\] VGND VGND VPWR VPWR net2101 sky130_fd_sc_hd__dlygate4sd3_1
X_10011_ clknet_leaf_124_clk _00135_ VGND VGND VPWR VPWR cpuregs\[30\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_1_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_110_2091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10913_ clknet_leaf_29_clk _00969_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dfxtp_1
X_10844_ clknet_leaf_87_clk _00903_ VGND VGND VPWR VPWR decoded_imm_j\[15\] sky130_fd_sc_hd__dfxtp_2
X_10775_ clknet_leaf_57_clk alu_out\[22\] VGND VGND VPWR VPWR alu_out_q\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_12_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_2201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11327_ clknet_leaf_33_clk _01368_ VGND VGND VPWR VPWR cpuregs\[5\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_10_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_113_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_122_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11258_ clknet_leaf_9_clk _01299_ VGND VGND VPWR VPWR cpuregs\[22\]\[13\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_79_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10209_ clknet_leaf_153_clk _00333_ VGND VGND VPWR VPWR cpuregs\[14\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_11189_ clknet_leaf_149_clk _01230_ VGND VGND VPWR VPWR cpuregs\[29\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_128_2385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05750_ _02119_ net583 net579 _02118_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__a22o_1
XFILLER_63_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05681_ _02129_ _02258_ VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__nand2_1
XFILLER_36_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07420_ net1471 net261 net441 VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_141_2585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07351_ net1645 net271 net448 VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06302_ instr_sll instr_slli _01554_ net508 _02733_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__o41a_1
X_07282_ net1731 net279 net456 VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__mux2_1
XFILLER_31_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09021_ _04681_ _04682_ net682 VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__mux2_1
X_06233_ reg_pc\[23\] _02669_ reg_pc\[24\] VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__a21oi_1
XFILLER_129_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold201 cpuregs\[30\]\[25\] VGND VGND VPWR VPWR net1309 sky130_fd_sc_hd__dlygate4sd3_1
X_06164_ net323 net2184 net476 VGND VGND VPWR VPWR _00047_ sky130_fd_sc_hd__mux2_1
XFILLER_144_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold212 cpuregs\[1\]\[16\] VGND VGND VPWR VPWR net1320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold234 cpuregs\[13\]\[16\] VGND VGND VPWR VPWR net1342 sky130_fd_sc_hd__dlygate4sd3_1
Xhold223 cpuregs\[20\]\[17\] VGND VGND VPWR VPWR net1331 sky130_fd_sc_hd__dlygate4sd3_1
X_05115_ _01702_ _01705_ VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__nor2_1
Xhold245 cpuregs\[1\]\[26\] VGND VGND VPWR VPWR net1353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold267 cpuregs\[25\]\[22\] VGND VGND VPWR VPWR net1375 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold256 cpuregs\[13\]\[12\] VGND VGND VPWR VPWR net1364 sky130_fd_sc_hd__dlygate4sd3_1
X_06095_ net674 _02560_ net665 VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__o21a_1
Xhold278 cpuregs\[14\]\[5\] VGND VGND VPWR VPWR net1386 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_148_2706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout703 net704 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__buf_2
X_09923_ clknet_leaf_22_clk _00052_ VGND VGND VPWR VPWR cpuregs\[11\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_05046_ net694 net699 VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__nand2b_1
Xfanout714 net715 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__clkbuf_4
Xhold289 cpuregs\[30\]\[2\] VGND VGND VPWR VPWR net1397 sky130_fd_sc_hd__dlygate4sd3_1
X_09854_ net274 net1866 net347 VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__mux2_1
Xfanout736 _00014_ VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__buf_4
Xfanout725 _00016_ VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__clkbuf_8
XFILLER_112_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout758 net765 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout747 net748 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout769 net771 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__clkbuf_2
XFILLER_105_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_105_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08805_ net893 _04486_ _04485_ net480 VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__o211a_1
XFILLER_58_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06997_ _03380_ _03383_ _03406_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__a21o_1
X_09785_ net283 net2103 net355 VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__mux2_1
X_05948_ net119 net212 net594 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__mux2_1
X_08736_ cpuregs\[28\]\[14\] cpuregs\[29\]\[14\] cpuregs\[30\]\[14\] cpuregs\[31\]\[14\]
+ net960 net925 VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__mux4_1
XANTENNA_107 net599 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_68_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05879_ _02092_ _02095_ _02420_ _02227_ VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__a31o_1
X_08667_ cpuregs\[4\]\[10\] cpuregs\[5\]\[10\] cpuregs\[6\]\[10\] cpuregs\[7\]\[10\]
+ net947 net912 VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__mux4_1
XFILLER_54_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07618_ net1898 net271 net416 VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__mux2_1
XFILLER_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08598_ _04281_ _04289_ _04290_ net658 net895 VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__a221o_1
X_07549_ net280 net2136 net423 VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__mux2_1
X_10560_ clknet_leaf_133_clk _00684_ VGND VGND VPWR VPWR reg_next_pc\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_14_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09219_ _04771_ _04799_ net550 VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__a21oi_1
X_10491_ clknet_leaf_110_clk _00615_ VGND VGND VPWR VPWR count_instr\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_107_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_112_2120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_79_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_112_2131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_688 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold790 cpuregs\[20\]\[22\] VGND VGND VPWR VPWR net1898 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_122_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11112_ clknet_leaf_100_clk _00019_ VGND VGND VPWR VPWR cpu_state\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_89_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11043_ clknet_leaf_87_clk _01094_ VGND VGND VPWR VPWR mem_rdata_q\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_77_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_103_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_92_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_91_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10827_ clknet_leaf_129_clk _00886_ VGND VGND VPWR VPWR decoded_imm_j\[4\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_99_1915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10758_ clknet_leaf_141_clk alu_out\[5\] VGND VGND VPWR VPWR alu_out_q\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10689_ clknet_leaf_145_clk _00781_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dfxtp_1
XFILLER_126_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06920_ net867 net509 net489 _03332_ VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__o211a_1
XFILLER_68_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_143_2625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06851_ net724 _03266_ _03265_ net518 VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__o211a_1
X_06782_ net862 net513 VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__or2_1
X_05802_ net829 _02112_ _02363_ _02364_ _02208_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__o32a_1
X_09570_ net1340 net527 net380 VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__mux2_1
X_05733_ net828 _02135_ _02193_ _02303_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__a31o_1
X_08521_ net895 _04219_ VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__nand2_1
X_08452_ cpuregs\[28\]\[31\] cpuregs\[29\]\[31\] cpuregs\[30\]\[31\] cpuregs\[31\]\[31\]
+ net796 net759 VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__mux4_1
XFILLER_91_792 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05664_ instr_and instr_andi VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__or2_2
X_07403_ net1352 net337 net438 VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__mux2_1
X_08383_ net2309 _04134_ net987 VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_63_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05595_ _02132_ _02142_ _02163_ _02166_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__and4_1
XFILLER_23_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_149_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07334_ net1511 net474 net446 VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__mux2_1
XFILLER_32_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07265_ net1589 net527 net455 VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__mux2_1
XFILLER_136_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09004_ net667 _04673_ _04674_ _04667_ net663 VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__a221o_1
X_06216_ reg_out\[21\] alu_out_q\[21\] net842 VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__mux2_1
X_07196_ net1571 net536 net465 VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__mux2_1
XFILLER_3_708 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06147_ reg_pc\[7\] reg_pc\[6\] _02599_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__and3_1
XFILLER_116_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06078_ net665 _02542_ _02546_ VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__a21oi_1
X_09906_ net1110 VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__clkbuf_1
Xfanout511 net512 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__buf_2
Xfanout522 _02718_ VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__clkbuf_4
Xfanout500 net501 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__clkbuf_2
X_05029_ net2340 _01606_ _01617_ net695 _01645_ VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__a221o_1
Xfanout533 _02588_ VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__clkbuf_2
Xfanout555 net556 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__buf_2
Xfanout544 _02247_ VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__buf_4
Xfanout566 _02582_ VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__buf_2
Xfanout577 _02246_ VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__buf_4
Xfanout599 _01640_ VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__clkbuf_4
Xfanout588 _01844_ VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__clkbuf_2
XFILLER_58_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09837_ net473 net2155 net345 VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__mux2_1
XFILLER_101_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_100_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09768_ net530 net1519 net354 VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__mux2_1
XFILLER_27_620 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_132_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08719_ cpuregs\[16\]\[13\] cpuregs\[17\]\[13\] cpuregs\[18\]\[13\] cpuregs\[19\]\[13\]
+ net948 net913 VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__mux4_1
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09699_ _03567_ _04873_ VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__or2_4
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10612_ clknet_leaf_89_clk _00736_ VGND VGND VPWR VPWR count_cycle\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10543_ clknet_leaf_65_clk _00667_ VGND VGND VPWR VPWR reg_pc\[23\] sky130_fd_sc_hd__dfxtp_2
XFILLER_127_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10474_ clknet_leaf_85_clk _00598_ VGND VGND VPWR VPWR count_instr\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_94_1834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11026_ clknet_leaf_33_clk _01082_ VGND VGND VPWR VPWR cpuregs\[19\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_125_2333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_597 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_29 _03574_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05380_ _01952_ _01955_ _01965_ VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_103_1985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_18 _02736_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07050_ net856 net512 _03385_ net498 VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__o211a_1
XFILLER_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06001_ reg_out\[21\] reg_next_pc\[21\] net573 VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__mux2_1
XFILLER_127_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput103 net103 VGND VGND VPWR VPWR mem_la_wdata[15] sky130_fd_sc_hd__buf_2
Xoutput114 net114 VGND VGND VPWR VPWR mem_la_wdata[25] sky130_fd_sc_hd__buf_2
Xoutput125 net125 VGND VGND VPWR VPWR mem_la_wdata[6] sky130_fd_sc_hd__buf_2
Xoutput147 net147 VGND VGND VPWR VPWR mem_wdata[20] sky130_fd_sc_hd__buf_2
Xoutput158 net158 VGND VGND VPWR VPWR mem_wdata[30] sky130_fd_sc_hd__buf_2
Xoutput136 net136 VGND VGND VPWR VPWR mem_wdata[10] sky130_fd_sc_hd__buf_2
XFILLER_142_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput169 net169 VGND VGND VPWR VPWR mem_wstrb[2] sky130_fd_sc_hd__buf_2
X_07952_ _03773_ _03774_ _03775_ net834 VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__o22a_1
X_06903_ cpuregs\[16\]\[21\] cpuregs\[17\]\[21\] cpuregs\[18\]\[21\] cpuregs\[19\]\[21\]
+ net797 net760 VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__mux4_1
X_07883_ net2377 net504 _03720_ net604 VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__a22o_1
XFILLER_68_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09622_ net272 net2222 net375 VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__mux2_1
X_06834_ net867 net509 _03175_ net497 VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__o211a_1
X_09553_ net1786 net285 net382 VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_39_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06765_ cpuregs\[8\]\[16\] cpuregs\[9\]\[16\] cpuregs\[10\]\[16\] cpuregs\[11\]\[16\]
+ net799 net762 VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__mux4_1
XFILLER_102_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08504_ mem_do_prefetch _01551_ _01638_ VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__mux2_1
X_09484_ net1648 net298 net391 VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__mux2_1
X_06696_ _03090_ _03094_ _03116_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__a21oi_1
X_05716_ _02164_ _02283_ _02165_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__a21bo_1
X_05647_ net858 _01566_ _02095_ _02226_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__a31o_1
X_08435_ _03533_ _03538_ _04168_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__a21o_1
X_08366_ count_cycle\[37\] count_cycle\[38\] count_cycle\[39\] _04120_ VGND VGND VPWR
+ VPWR _04125_ sky130_fd_sc_hd__and4_1
XFILLER_137_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07317_ net1676 net273 net451 VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__mux2_1
X_05578_ net874 net206 VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__nor2_1
X_08297_ count_cycle\[13\] _04080_ net987 VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__o21ai_1
XFILLER_137_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07248_ net1619 net283 net460 VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__mux2_1
X_07179_ net1905 net281 net468 VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10190_ clknet_leaf_41_clk _00314_ VGND VGND VPWR VPWR cpuregs\[9\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_76_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_120_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout341 net342 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__clkbuf_2
Xfanout330 net331 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__clkbuf_4
Xfanout352 _04878_ VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkbuf_4
Xfanout363 net364 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__clkbuf_8
XFILLER_47_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout374 _04871_ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__clkbuf_4
XFILLER_87_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout396 _04866_ VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__buf_4
Xfanout385 net386 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_107_2041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_2252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput16 mem_rdata[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_2
XFILLER_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput27 mem_rdata[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_7_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10526_ clknet_leaf_127_clk _00650_ VGND VGND VPWR VPWR reg_pc\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10457_ clknet_leaf_111_clk _00581_ VGND VGND VPWR VPWR count_instr\[0\] sky130_fd_sc_hd__dfxtp_1
X_10388_ clknet_leaf_77_clk _00512_ VGND VGND VPWR VPWR cpuregs\[25\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_97_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_560 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11009_ clknet_leaf_123_clk _01065_ VGND VGND VPWR VPWR cpuregs\[19\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_38_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06550_ cpuregs\[0\]\[8\] cpuregs\[1\]\[8\] cpuregs\[2\]\[8\] cpuregs\[3\]\[8\] net773
+ net737 VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__mux4_1
XFILLER_33_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05501_ net853 net224 VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__nor2_1
X_06481_ _02908_ _02909_ VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__nand2_1
X_08220_ net814 _03725_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__xnor2_1
X_05432_ _02001_ _02002_ _02003_ VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__a21bo_1
XFILLER_21_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08151_ _03954_ _03957_ net685 VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__a21o_1
X_05363_ reg_pc\[24\] decoded_imm\[24\] VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__or2_1
XFILLER_147_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07102_ reg_pc\[28\] net562 _03508_ net519 net522 VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__a221o_1
X_08082_ decoded_imm_j\[17\] _03713_ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__nand2_1
X_05294_ count_cycle\[18\] net618 net590 _01887_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_151_2746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07033_ cpuregs\[4\]\[26\] cpuregs\[5\]\[26\] cpuregs\[6\]\[26\] cpuregs\[7\]\[26\]
+ net800 net763 VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_58_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08984_ _04645_ _04646_ net683 VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__mux2_1
XFILLER_115_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_88_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07935_ _03748_ _03758_ _03759_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__and3_1
XFILLER_130_789 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07866_ reg_pc\[15\] net504 _03711_ net604 VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__a22o_1
X_09605_ net474 net1766 net373 VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__mux2_1
XFILLER_29_759 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06817_ cpuregs\[28\]\[18\] cpuregs\[29\]\[18\] cpuregs\[30\]\[18\] cpuregs\[31\]\[18\]
+ net793 net756 VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__mux4_1
X_07797_ _03671_ net995 _03670_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_3_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06748_ _03069_ _03163_ _03165_ _03166_ VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__o211ai_2
XFILLER_71_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09536_ net1763 net531 net384 VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__mux2_1
XFILLER_37_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09467_ latched_rd\[1\] latched_rd\[0\] _03575_ VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__nor3b_4
XFILLER_36_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08418_ count_cycle\[58\] _04157_ net1000 VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__o21ai_1
X_06679_ cpuregs\[12\]\[13\] cpuregs\[13\]\[13\] cpuregs\[14\]\[13\] cpuregs\[15\]\[13\]
+ net780 net744 VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__mux4_1
XFILLER_51_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09398_ mem_rdata_q\[21\] _04794_ VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__and2_1
X_08349_ _04114_ net979 _04113_ VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_22_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11360_ clknet_leaf_55_clk _01398_ VGND VGND VPWR VPWR cpuregs\[6\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_22_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_138_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10311_ clknet_leaf_17_clk _00435_ VGND VGND VPWR VPWR cpuregs\[26\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11291_ clknet_leaf_9_clk _01332_ VGND VGND VPWR VPWR cpuregs\[4\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10242_ clknet_leaf_14_clk _00366_ VGND VGND VPWR VPWR cpuregs\[27\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10173_ clknet_leaf_140_clk _00297_ VGND VGND VPWR VPWR cpuregs\[9\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_94_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_100_1933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10509_ clknet_leaf_84_clk _00633_ VGND VGND VPWR VPWR count_instr\[52\] sky130_fd_sc_hd__dfxtp_1
Xhold608 instr_sltiu VGND VGND VPWR VPWR net1716 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_133_2465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold619 cpuregs\[11\]\[16\] VGND VGND VPWR VPWR net1727 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11489_ clknet_leaf_31_clk _01527_ VGND VGND VPWR VPWR cpuregs\[10\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_152_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07720_ _03618_ _03622_ VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__nand2_1
XFILLER_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05981_ reg_out\[11\] reg_next_pc\[11\] net569 VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04932_ net108 VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__inv_2
X_07651_ net271 net2160 net412 VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__mux2_1
XFILLER_93_684 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07582_ net2218 net282 net420 VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__mux2_1
XFILLER_81_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06602_ cpuregs\[16\]\[10\] cpuregs\[17\]\[10\] cpuregs\[18\]\[10\] cpuregs\[19\]\[10\]
+ net782 net746 VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_0_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06533_ _02958_ _02959_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__nand2_1
X_09321_ latched_rd\[3\] _04818_ _04819_ net1250 VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__a22o_1
X_09252_ net1282 net261 net405 VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__mux2_1
X_06464_ net731 _02893_ net638 VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__o21a_1
X_08203_ net837 _04005_ _04006_ _04004_ VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__o31a_1
X_05415_ _01996_ _01998_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__and2_1
X_09183_ net817 net549 _04787_ _04789_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__a22o_1
X_06395_ cpuregs\[4\]\[3\] cpuregs\[5\]\[3\] cpuregs\[6\]\[3\] cpuregs\[7\]\[3\] net786
+ net750 VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__mux4_1
X_08134_ net812 _03718_ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__xor2_1
X_05346_ net590 _01933_ _01934_ _01935_ VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__a31o_1
XFILLER_146_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_108_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05277_ _01870_ _01871_ VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__nand2_1
X_08065_ net559 _03878_ _03879_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__a21o_1
X_07016_ reg_pc\[25\] net562 _03425_ net519 net522 VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_73_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08967_ net904 _04636_ _04635_ net663 VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__o211a_1
XFILLER_130_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08898_ net680 _04573_ VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__or2_1
XFILLER_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07918_ _03740_ _03741_ net687 VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_104_2000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07849_ _02605_ reg_next_pc\[7\] net570 VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__mux2_2
XFILLER_71_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10860_ clknet_leaf_96_clk net1717 VGND VGND VPWR VPWR is_sltiu_bltu_sltu sky130_fd_sc_hd__dfxtp_1
X_09519_ net1570 net290 net387 VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__mux2_1
XFILLER_17_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_84_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10791_ clknet_leaf_96_clk _00850_ VGND VGND VPWR VPWR instr_bge sky130_fd_sc_hd__dfxtp_1
XFILLER_24_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11412_ clknet_leaf_126_clk _01450_ VGND VGND VPWR VPWR cpuregs\[8\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_115_2173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11343_ clknet_leaf_101_clk _00026_ VGND VGND VPWR VPWR mem_wordsize\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_153_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11274_ clknet_leaf_73_clk _01315_ VGND VGND VPWR VPWR cpuregs\[22\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10225_ clknet_leaf_49_clk _00349_ VGND VGND VPWR VPWR cpuregs\[14\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_134_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_467 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10156_ clknet_leaf_37_clk _00280_ VGND VGND VPWR VPWR cpuregs\[21\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_94_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10087_ clknet_leaf_11_clk _00211_ VGND VGND VPWR VPWR cpuregs\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xhold5 cpuregs\[0\]\[6\] VGND VGND VPWR VPWR net1113 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10989_ clknet_leaf_11_clk _01045_ VGND VGND VPWR VPWR cpuregs\[18\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_62_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_773 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05200_ _01770_ _01781_ _01792_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__nor3_1
X_06180_ _02630_ _02633_ net566 VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__mux2_1
Xhold416 cpuregs\[2\]\[25\] VGND VGND VPWR VPWR net1524 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05131_ count_instr\[38\] net815 net824 count_cycle\[38\] VGND VGND VPWR VPWR _01737_
+ sky130_fd_sc_hd__a22o_1
Xhold405 cpuregs\[4\]\[3\] VGND VGND VPWR VPWR net1513 sky130_fd_sc_hd__dlygate4sd3_1
Xhold427 cpuregs\[22\]\[9\] VGND VGND VPWR VPWR net1535 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold449 cpuregs\[24\]\[14\] VGND VGND VPWR VPWR net1557 sky130_fd_sc_hd__dlygate4sd3_1
Xhold438 cpuregs\[20\]\[4\] VGND VGND VPWR VPWR net1546 sky130_fd_sc_hd__dlygate4sd3_1
X_05062_ reg_pc\[1\] decoded_imm\[1\] VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__nand2_1
XFILLER_98_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09870_ decoded_imm_j\[17\] _01111_ net332 VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__mux2_1
Xfanout907 net917 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__clkbuf_4
Xfanout929 net933 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__clkbuf_4
X_08821_ _04492_ _04493_ net677 VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__mux2_1
XFILLER_98_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_86_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_5_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout918 net919 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__clkbuf_4
Xhold1105 cpuregs\[19\]\[24\] VGND VGND VPWR VPWR net2213 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_58_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_146_2667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1127 cpuregs\[6\]\[29\] VGND VGND VPWR VPWR net2235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1116 cpuregs\[18\]\[23\] VGND VGND VPWR VPWR net2224 sky130_fd_sc_hd__dlygate4sd3_1
X_08752_ decoded_imm\[14\] net598 net627 VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__a21o_1
Xhold1138 instr_or VGND VGND VPWR VPWR net2246 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1149 instr_slli VGND VGND VPWR VPWR net2257 sky130_fd_sc_hd__dlygate4sd3_1
X_05964_ net193 _02484_ net634 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__mux2_1
X_07703_ count_instr\[15\] count_instr\[14\] _03608_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__and3_1
XFILLER_72_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04915_ instr_bne VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__inv_2
X_08683_ cpuregs\[28\]\[11\] cpuregs\[29\]\[11\] cpuregs\[30\]\[11\] cpuregs\[31\]\[11\]
+ net947 net912 VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__mux4_1
X_05895_ _02086_ net586 net577 _02087_ _02446_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__a221o_1
X_07634_ net473 net2042 net410 VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__mux2_1
XFILLER_53_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_66_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07565_ net1247 net528 net419 VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1023 VGND VGND VPWR VPWR picorv32_1023/HI eoi[20] sky130_fd_sc_hd__conb_1
XFILLER_139_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xpicorv32_1012 VGND VGND VPWR VPWR picorv32_1012/HI eoi[9] sky130_fd_sc_hd__conb_1
X_09304_ net1183 net118 net484 VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1034 VGND VGND VPWR VPWR picorv32_1034/HI eoi[31] sky130_fd_sc_hd__conb_1
X_07496_ net1602 net536 net427 VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__mux2_1
X_06516_ cpuregs\[8\]\[7\] cpuregs\[9\]\[7\] cpuregs\[10\]\[7\] cpuregs\[11\]\[7\]
+ net776 net740 VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__mux4_1
Xpicorv32_1067 VGND VGND VPWR VPWR picorv32_1067/HI pcpi_insn[28] sky130_fd_sc_hd__conb_1
Xpicorv32_1056 VGND VGND VPWR VPWR picorv32_1056/HI pcpi_insn[17] sky130_fd_sc_hd__conb_1
XFILLER_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_787 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09235_ net1266 net335 net402 VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1045 VGND VGND VPWR VPWR picorv32_1045/HI pcpi_insn[6] sky130_fd_sc_hd__conb_1
X_06447_ decoded_imm\[5\] net880 VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__or2_1
Xpicorv32_1078 VGND VGND VPWR VPWR picorv32_1078/HI trace_data[6] sky130_fd_sc_hd__conb_1
Xpicorv32_1089 VGND VGND VPWR VPWR picorv32_1089/HI trace_data[17] sky130_fd_sc_hd__conb_1
X_09166_ mem_rdata_q\[17\] mem_rdata_q\[16\] mem_rdata_q\[15\] mem_rdata_q\[2\] VGND
+ VGND VPWR VPWR _04781_ sky130_fd_sc_hd__or4_1
X_06378_ _01626_ _02810_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__or2_1
XFILLER_135_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08117_ _03716_ _03914_ VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__and2_1
X_05329_ count_instr\[53\] net816 net822 count_instr\[21\] VGND VGND VPWR VPWR _01920_
+ sky130_fd_sc_hd__a22o_1
X_09097_ net719 mem_rdata_q\[13\] net721 VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__nor3_2
X_08048_ _03709_ _03710_ _03839_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__and3_1
Xhold961 cpuregs\[22\]\[26\] VGND VGND VPWR VPWR net2069 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold972 cpuregs\[10\]\[4\] VGND VGND VPWR VPWR net2080 sky130_fd_sc_hd__dlygate4sd3_1
Xhold950 cpuregs\[6\]\[0\] VGND VGND VPWR VPWR net2058 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_135_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_531 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold983 cpuregs\[9\]\[19\] VGND VGND VPWR VPWR net2091 sky130_fd_sc_hd__dlygate4sd3_1
Xhold994 cpuregs\[10\]\[17\] VGND VGND VPWR VPWR net2102 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_88_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10010_ clknet_leaf_116_clk _00134_ VGND VGND VPWR VPWR cpuregs\[30\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_09999_ clknet_leaf_47_clk _00123_ VGND VGND VPWR VPWR cpuregs\[12\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_131_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_2092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10912_ clknet_leaf_6_clk _00968_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dfxtp_1
XFILLER_72_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10843_ clknet_leaf_111_clk _00902_ VGND VGND VPWR VPWR decoded_rd\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10774_ clknet_leaf_57_clk alu_out\[21\] VGND VGND VPWR VPWR alu_out_q\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_2202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_138_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_97_1887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11326_ clknet_leaf_28_clk _01367_ VGND VGND VPWR VPWR cpuregs\[5\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_10_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11257_ clknet_leaf_7_clk _01298_ VGND VGND VPWR VPWR cpuregs\[22\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_11188_ clknet_leaf_146_clk _01229_ VGND VGND VPWR VPWR cpuregs\[29\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_10208_ clknet_leaf_150_clk _00332_ VGND VGND VPWR VPWR cpuregs\[14\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_10139_ clknet_leaf_122_clk _00263_ VGND VGND VPWR VPWR cpuregs\[21\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_128_2386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05680_ _02185_ _02257_ net692 VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_141_2586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07350_ net1607 net275 net448 VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__mux2_1
XFILLER_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06301_ instr_srl instr_srli _02734_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__or3_4
XFILLER_148_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09020_ _04680_ _04688_ _04689_ net663 net898 VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__a221o_1
X_07281_ net1366 net284 net456 VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_151_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_151_clk sky130_fd_sc_hd__clkbuf_8
X_06232_ reg_out\[24\] alu_out_q\[24\] net842 VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__mux2_1
X_06163_ _02618_ _02619_ net565 VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__mux2_2
Xhold202 cpuregs\[4\]\[4\] VGND VGND VPWR VPWR net1310 sky130_fd_sc_hd__dlygate4sd3_1
Xhold213 cpuregs\[25\]\[29\] VGND VGND VPWR VPWR net1321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold224 cpuregs\[1\]\[1\] VGND VGND VPWR VPWR net1332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold235 cpuregs\[25\]\[5\] VGND VGND VPWR VPWR net1343 sky130_fd_sc_hd__dlygate4sd3_1
X_05114_ _01662_ _01720_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__or2_1
XFILLER_144_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold268 cpuregs\[12\]\[16\] VGND VGND VPWR VPWR net1376 sky130_fd_sc_hd__dlygate4sd3_1
Xhold246 cpuregs\[13\]\[18\] VGND VGND VPWR VPWR net1354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold257 cpuregs\[4\]\[7\] VGND VGND VPWR VPWR net1365 sky130_fd_sc_hd__dlygate4sd3_1
X_06094_ _00009_ _02561_ VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_148_2707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_131_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout715 net716 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__clkbuf_4
Xfanout704 cpu_state\[6\] VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__buf_2
Xhold279 cpuregs\[12\]\[15\] VGND VGND VPWR VPWR net1387 sky130_fd_sc_hd__dlygate4sd3_1
X_09922_ clknet_leaf_9_clk _00051_ VGND VGND VPWR VPWR cpuregs\[11\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_05045_ net887 net698 _01657_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__and3_1
X_09853_ net277 net2127 net347 VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__mux2_1
XFILLER_86_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout748 net772 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__buf_2
Xfanout726 net727 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__clkbuf_8
Xfanout737 net738 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09784_ net287 net2157 net355 VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__mux2_1
Xfanout759 net765 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__buf_2
X_08804_ _04474_ _04475_ _04478_ _04479_ net677 net666 VGND VGND VPWR VPWR _04486_
+ sky130_fd_sc_hd__mux4_1
XFILLER_86_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06996_ _03404_ _03405_ VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__nand2b_1
X_08735_ cpuregs\[24\]\[14\] cpuregs\[25\]\[14\] cpuregs\[26\]\[14\] cpuregs\[27\]\[14\]
+ net949 net914 VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_0_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_589 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05947_ net108 net211 net594 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__mux2_1
XANTENNA_108 net640 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_05878_ net542 _02430_ _02432_ VGND VGND VPWR VPWR alu_out\[25\] sky130_fd_sc_hd__o21ai_1
X_08666_ cpuregs\[24\]\[10\] cpuregs\[25\]\[10\] cpuregs\[26\]\[10\] cpuregs\[27\]\[10\]
+ net950 net915 VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__mux4_1
X_07617_ net1664 net275 net416 VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__mux2_1
X_08597_ _04284_ _04285_ net670 VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__mux2_1
X_07548_ net286 net2040 net423 VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07479_ net1363 net294 net432 VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__mux2_1
XFILLER_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_142_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_142_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_108_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09218_ mem_rdata_q\[31\] _04769_ mem_rdata_q\[29\] _04755_ VGND VGND VPWR VPWR _04799_
+ sky130_fd_sc_hd__or4b_1
XFILLER_10_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10490_ clknet_leaf_110_clk _00614_ VGND VGND VPWR VPWR count_instr\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09149_ mem_rdata_q\[31\] mem_rdata_q\[29\] mem_rdata_q\[30\] VGND VGND VPWR VPWR
+ _04774_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_112_2121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_667 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_146_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11111_ clknet_leaf_100_clk _00018_ VGND VGND VPWR VPWR cpu_state\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold791 cpuregs\[18\]\[29\] VGND VGND VPWR VPWR net1899 sky130_fd_sc_hd__dlygate4sd3_1
Xhold780 cpuregs\[18\]\[18\] VGND VGND VPWR VPWR net1888 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11042_ clknet_leaf_88_clk _00036_ VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__dfxtp_1
XFILLER_49_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10826_ clknet_leaf_87_clk _00885_ VGND VGND VPWR VPWR instr_rdinstrh sky130_fd_sc_hd__dfxtp_1
XFILLER_9_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_133_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_133_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_15_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10757_ clknet_leaf_141_clk alu_out\[4\] VGND VGND VPWR VPWR alu_out_q\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10688_ clknet_leaf_145_clk _00780_ VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dfxtp_1
XFILLER_126_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11309_ clknet_leaf_14_clk _01350_ VGND VGND VPWR VPWR cpuregs\[5\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06850_ _03254_ _03255_ _03259_ _03260_ net652 net728 VGND VGND VPWR VPWR _03266_
+ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_143_2615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05801_ _02113_ _02206_ net829 VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_143_2626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06781_ net607 _03196_ _03198_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__and3_1
X_05732_ net828 net877 _01564_ _02302_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__a31o_1
X_08520_ _04217_ _04218_ net901 VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__mux2_1
XFILLER_36_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08451_ _04178_ _04184_ net642 VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__mux2_1
X_05663_ instr_and instr_andi VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__nor2_1
XFILLER_51_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07402_ net1307 net340 net438 VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__mux2_1
XFILLER_23_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08382_ count_cycle\[43\] count_cycle\[44\] count_cycle\[45\] _04130_ VGND VGND VPWR
+ VPWR _04135_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_63_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05594_ _02129_ _02145_ _02169_ _02172_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_34_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_124_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_124_clk sky130_fd_sc_hd__clkbuf_8
X_07333_ net1527 net493 net449 VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__mux2_1
XFILLER_32_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07264_ net1438 net530 net455 VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__mux2_1
X_09003_ net682 _04665_ net898 VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__o21a_1
X_06215_ net281 net2007 net478 VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__mux2_1
X_07195_ net1520 _02584_ net462 VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__mux2_1
X_06146_ reg_pc\[6\] _02599_ reg_pc\[7\] VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__a21oi_1
X_06077_ net896 _02545_ net891 VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__a21o_1
X_09905_ net1109 VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__clkbuf_1
XFILLER_120_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout512 _02736_ VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__buf_1
Xfanout501 _04748_ VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__buf_2
X_05028_ instr_lhu instr_lh _01619_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__o21a_1
Xfanout523 net526 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__clkbuf_4
XFILLER_86_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout534 net535 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__clkbuf_2
Xfanout545 _01631_ VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__clkbuf_4
Xfanout556 _04746_ VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout567 net568 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__clkbuf_4
Xfanout589 net592 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__clkbuf_4
Xfanout578 _02245_ VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__clkbuf_4
X_09836_ net492 net2080 net346 VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__mux2_1
X_06979_ cpuregs\[28\]\[24\] cpuregs\[29\]\[24\] cpuregs\[30\]\[24\] cpuregs\[31\]\[24\]
+ net804 net767 VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__mux4_1
XFILLER_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09767_ net536 net2180 net354 VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__mux2_1
XFILLER_100_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09698_ net1367 net237 net367 VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__mux2_1
XFILLER_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08718_ cpuregs\[20\]\[13\] cpuregs\[21\]\[13\] cpuregs\[22\]\[13\] cpuregs\[23\]\[13\]
+ net948 net913 VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__mux4_1
XFILLER_27_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08649_ cpuregs\[0\]\[9\] cpuregs\[1\]\[9\] cpuregs\[2\]\[9\] cpuregs\[3\]\[9\] net942
+ net907 VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__mux4_1
XFILLER_148_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_54_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10611_ clknet_leaf_89_clk _00735_ VGND VGND VPWR VPWR count_cycle\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_12_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_115_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_115_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10542_ clknet_leaf_61_clk _00666_ VGND VGND VPWR VPWR reg_pc\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10473_ clknet_leaf_85_clk _00597_ VGND VGND VPWR VPWR count_instr\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_94_1835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_63_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_110_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11025_ clknet_leaf_20_clk _01081_ VGND VGND VPWR VPWR cpuregs\[19\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_125_2334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_72_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_103_1986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_19 _02739_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_103_1975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_106_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_106_clk sky130_fd_sc_hd__clkbuf_8
X_10809_ clknet_leaf_98_clk _00868_ VGND VGND VPWR VPWR instr_slli sky130_fd_sc_hd__dfxtp_1
XFILLER_60_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06000_ net864 _02502_ net636 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__mux2_2
Xoutput104 net104 VGND VGND VPWR VPWR mem_la_wdata[16] sky130_fd_sc_hd__buf_2
Xoutput115 net115 VGND VGND VPWR VPWR mem_la_wdata[26] sky130_fd_sc_hd__buf_2
XFILLER_141_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput159 net159 VGND VGND VPWR VPWR mem_wdata[31] sky130_fd_sc_hd__buf_2
Xoutput148 net148 VGND VGND VPWR VPWR mem_wdata[21] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_81_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput137 net137 VGND VGND VPWR VPWR mem_wdata[11] sky130_fd_sc_hd__buf_2
Xoutput126 net844 VGND VGND VPWR VPWR mem_la_wdata[7] sky130_fd_sc_hd__buf_2
XFILLER_130_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07951_ _03702_ _03763_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__xnor2_1
X_06902_ cpuregs\[20\]\[21\] cpuregs\[21\]\[21\] cpuregs\[22\]\[21\] cpuregs\[23\]\[21\]
+ net797 net760 VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__mux4_1
X_07882_ _02672_ reg_next_pc\[23\] net573 VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__mux2_2
XFILLER_96_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09621_ net275 net2099 net375 VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__mux2_1
X_06833_ _03247_ _03248_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__xnor2_1
XFILLER_28_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06764_ cpuregs\[12\]\[16\] cpuregs\[13\]\[16\] cpuregs\[14\]\[16\] cpuregs\[15\]\[16\]
+ net799 net764 VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__mux4_1
X_09552_ net1948 net287 net383 VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__mux2_1
XFILLER_83_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08503_ net88 net1178 net409 VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__mux2_1
XFILLER_102_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_90_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05715_ _02286_ _02287_ _02288_ VGND VGND VPWR VPWR alu_out\[6\] sky130_fd_sc_hd__or3_1
X_06695_ decoded_imm\[14\] net872 VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__xnor2_1
X_09483_ net1824 net301 net390 VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__mux2_1
XFILLER_64_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05646_ net220 net857 VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__and2b_1
X_08434_ decoded_imm\[31\] net852 VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__xnor2_1
XFILLER_12_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05577_ net874 net206 VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__and2_1
X_08365_ _04124_ net981 _04123_ VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__and3b_1
XFILLER_11_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07316_ net2026 net278 net451 VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__mux2_1
XFILLER_32_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08296_ _04080_ _04081_ VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__nor2_1
XFILLER_137_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07247_ net1354 net289 net460 VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__mux2_1
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_152_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07178_ net1470 net284 net468 VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06129_ reg_out\[4\] alu_out_q\[4\] net840 VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__mux2_1
Xfanout331 _02514_ VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__clkbuf_4
Xfanout320 net322 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__clkbuf_2
Xfanout364 _04875_ VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__buf_4
Xfanout375 net376 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkbuf_8
XFILLER_87_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout353 net354 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkbuf_8
Xfanout342 _02609_ VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_143_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09819_ net281 net2225 net351 VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__mux2_1
XFILLER_101_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout386 _04868_ VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__clkbuf_4
Xfanout397 net400 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_129_Left_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_107_2042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_70_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_138_Left_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput28 mem_rdata[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
Xinput17 mem_rdata[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_2
X_10525_ clknet_leaf_127_clk _00649_ VGND VGND VPWR VPWR reg_pc\[5\] sky130_fd_sc_hd__dfxtp_1
X_10456_ clknet_leaf_101_clk _00580_ VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dfxtp_4
XFILLER_7_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10387_ clknet_leaf_67_clk _00511_ VGND VGND VPWR VPWR cpuregs\[25\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_123_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_97_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11008_ clknet_leaf_119_clk _01064_ VGND VGND VPWR VPWR cpuregs\[19\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05500_ net853 net224 VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__nand2_1
X_06480_ decoded_imm\[6\] net879 VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__nand2_1
X_05431_ _02012_ _02013_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__nor2_1
XFILLER_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08150_ _03954_ _03957_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__nor2_1
XFILLER_33_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07101_ _03504_ _03505_ _03506_ _03507_ net730 net725 VGND VGND VPWR VPWR _03508_
+ sky130_fd_sc_hd__mux4_1
X_05362_ _01905_ _01915_ _01947_ _01949_ VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__a31o_1
X_08081_ decoded_imm_j\[17\] _03713_ VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__or2_1
X_05293_ count_instr\[18\] net821 net624 _01886_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_151_2747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07032_ cpuregs\[24\]\[26\] cpuregs\[25\]\[26\] cpuregs\[26\]\[26\] cpuregs\[27\]\[26\]
+ net803 net766 VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__mux4_1
XFILLER_114_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_605 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08983_ net905 _04654_ net663 VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__o21a_1
XFILLER_87_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07934_ _03740_ _03741_ _03749_ _03738_ VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__o211ai_1
XFILLER_84_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07865_ _02638_ reg_next_pc\[15\] net572 VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__mux2_2
XFILLER_68_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_84_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09604_ net492 net2122 net374 VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__mux2_1
X_06816_ cpuregs\[8\]\[18\] cpuregs\[9\]\[18\] cpuregs\[10\]\[18\] cpuregs\[11\]\[18\]
+ net792 net755 VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__mux4_1
XFILLER_84_888 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07796_ count_instr\[49\] count_instr\[48\] _03667_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__and3_1
XFILLER_71_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06747_ _03116_ _03140_ _03164_ _03139_ VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__o31a_1
XFILLER_71_527 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09535_ net1523 net535 net384 VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__mux2_1
X_09466_ net236 net2065 net394 VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__mux2_1
X_06678_ net495 _03017_ _03099_ _03098_ VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__a31o_1
XFILLER_24_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08417_ _04157_ net1002 _04156_ VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__and3b_1
X_05629_ _02050_ _02208_ _02207_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__a21o_1
XFILLER_52_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09397_ decoded_imm\[2\] net552 _04861_ _04862_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__o22a_1
XFILLER_138_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08348_ count_cycle\[32\] count_cycle\[31\] _04110_ VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_22_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08279_ net2310 _04069_ net982 VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__o21ai_1
XFILLER_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_98_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10310_ clknet_leaf_27_clk _00434_ VGND VGND VPWR VPWR cpuregs\[26\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_11290_ clknet_leaf_9_clk _01331_ VGND VGND VPWR VPWR cpuregs\[4\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10241_ clknet_leaf_151_clk _00365_ VGND VGND VPWR VPWR cpuregs\[27\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10172_ clknet_leaf_142_clk _00296_ VGND VGND VPWR VPWR cpuregs\[9\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_146_Left_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10508_ clknet_leaf_84_clk _00632_ VGND VGND VPWR VPWR count_instr\[51\] sky130_fd_sc_hd__dfxtp_1
Xhold609 _00003_ VGND VGND VPWR VPWR net1717 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_133_2466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_2455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11488_ clknet_leaf_54_clk _01526_ VGND VGND VPWR VPWR cpuregs\[10\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_143_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10439_ clknet_leaf_21_clk _00563_ VGND VGND VPWR VPWR cpuregs\[17\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05980_ net875 _02492_ net634 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_04931_ net847 VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__inv_2
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07650_ net275 net2022 net412 VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__mux2_1
XFILLER_66_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07581_ net1287 net285 net420 VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__mux2_1
XFILLER_81_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06601_ net732 _03025_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__or2_1
XFILLER_53_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06532_ decoded_imm\[8\] net877 VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__nand2_1
X_09320_ latched_rd\[2\] _04818_ _04819_ net1193 VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__a22o_1
XFILLER_34_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09251_ net1568 net265 net405 VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__mux2_1
X_08202_ _03722_ _03981_ _03723_ VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__a21oi_1
X_06463_ cpuregs\[0\]\[5\] cpuregs\[1\]\[5\] cpuregs\[2\]\[5\] cpuregs\[3\]\[5\] net775
+ net739 VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__mux4_1
XFILLER_138_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05414_ reg_pc\[24\] decoded_imm\[24\] _01962_ _01964_ VGND VGND VPWR VPWR _01998_
+ sky130_fd_sc_hd__a31o_1
X_09182_ net990 _04760_ _04793_ net501 net1117 VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__a32o_1
X_06394_ net650 _02823_ _02825_ net638 VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__a211o_1
XFILLER_119_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08133_ _03718_ _03936_ net685 VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__o21a_1
X_05345_ net709 net861 _01929_ net715 _01931_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__a221o_1
X_08064_ net689 reg_next_pc\[15\] net546 _03711_ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__a22o_1
X_07015_ _03421_ _03422_ _03423_ _03424_ net730 net639 VGND VGND VPWR VPWR _03425_
+ sky130_fd_sc_hd__mux4_1
X_05276_ reg_pc\[17\] decoded_imm\[17\] VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_73_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08966_ _04631_ _04637_ _04638_ net661 net898 VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__a221o_1
X_08897_ cpuregs\[20\]\[23\] cpuregs\[21\]\[23\] cpuregs\[22\]\[23\] cpuregs\[23\]\[23\]
+ net966 net931 VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__mux4_1
XFILLER_84_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_95_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_95_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_75_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07917_ _03697_ _03699_ VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_104_2001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07848_ reg_pc\[6\] net502 _03702_ net602 VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__a22o_1
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09518_ net1362 net293 net387 VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__mux2_1
XFILLER_72_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07779_ count_instr\[42\] _03657_ count_instr\[43\] VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_27_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10790_ clknet_leaf_96_clk _00849_ VGND VGND VPWR VPWR instr_blt sky130_fd_sc_hd__dfxtp_1
XFILLER_52_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09449_ net308 net1914 net394 VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__mux2_1
XFILLER_40_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11411_ clknet_leaf_126_clk _01449_ VGND VGND VPWR VPWR cpuregs\[8\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11342_ clknet_leaf_101_clk _00025_ VGND VGND VPWR VPWR mem_wordsize\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11273_ clknet_leaf_73_clk _01314_ VGND VGND VPWR VPWR cpuregs\[22\]\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_115_2174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_152_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_134_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10224_ clknet_leaf_51_clk _00348_ VGND VGND VPWR VPWR cpuregs\[14\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_10155_ clknet_leaf_23_clk _00279_ VGND VGND VPWR VPWR cpuregs\[21\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_800 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_86_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_86_clk sky130_fd_sc_hd__clkbuf_8
X_10086_ clknet_leaf_29_clk _00210_ VGND VGND VPWR VPWR cpuregs\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold6 cpuregs\[0\]\[9\] VGND VGND VPWR VPWR net1114 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10988_ clknet_leaf_29_clk _01044_ VGND VGND VPWR VPWR cpuregs\[18\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_10_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
X_05130_ net15 _01656_ net130 net29 _01735_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__a221o_1
Xhold417 cpuregs\[14\]\[20\] VGND VGND VPWR VPWR net1525 sky130_fd_sc_hd__dlygate4sd3_1
Xhold406 cpuregs\[27\]\[8\] VGND VGND VPWR VPWR net1514 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_55_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold439 cpuregs\[1\]\[7\] VGND VGND VPWR VPWR net1547 sky130_fd_sc_hd__dlygate4sd3_1
Xhold428 cpuregs\[20\]\[9\] VGND VGND VPWR VPWR net1536 sky130_fd_sc_hd__dlygate4sd3_1
X_05061_ count_cycle\[1\] net617 net589 _01671_ VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__o211a_1
XFILLER_143_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08820_ _04491_ _04499_ _04500_ net662 net897 VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__a221o_1
XFILLER_98_744 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout908 net910 VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__clkbuf_4
Xfanout919 net922 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__buf_2
XFILLER_85_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1106 cpuregs\[27\]\[1\] VGND VGND VPWR VPWR net2214 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_39_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_77_clk clknet_4_15_0_clk VGND VGND VPWR VPWR clknet_leaf_77_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_146_2668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1128 cpuregs\[11\]\[31\] VGND VGND VPWR VPWR net2236 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1117 cpuregs\[8\]\[20\] VGND VGND VPWR VPWR net2225 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_97_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08751_ _04434_ _04435_ net480 _04432_ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__o211a_1
Xhold1139 instr_sll VGND VGND VPWR VPWR net2247 sky130_fd_sc_hd__dlygate4sd3_1
X_05963_ reg_out\[2\] reg_next_pc\[2\] net571 VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__mux2_1
X_05894_ _02085_ net582 VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__nor2_1
X_07702_ count_instr\[14\] _03608_ count_instr\[15\] VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__a21o_1
XFILLER_66_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04914_ instr_bgeu VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__inv_2
X_08682_ cpuregs\[8\]\[11\] cpuregs\[9\]\[11\] cpuregs\[10\]\[11\] cpuregs\[11\]\[11\]
+ net946 net911 VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__mux4_1
X_07633_ net493 net1389 net411 VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__mux2_1
XFILLER_38_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_677 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07564_ net1460 net532 net419 VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1024 VGND VGND VPWR VPWR picorv32_1024/HI eoi[21] sky130_fd_sc_hd__conb_1
Xpicorv32_1013 VGND VGND VPWR VPWR picorv32_1013/HI eoi[10] sky130_fd_sc_hd__conb_1
X_09303_ net1164 net117 net484 VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06515_ cpuregs\[12\]\[7\] cpuregs\[13\]\[7\] cpuregs\[14\]\[7\] cpuregs\[15\]\[7\]
+ net775 net739 VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__mux4_1
X_07495_ net1426 net540 net426 VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1068 VGND VGND VPWR VPWR picorv32_1068/HI pcpi_insn[29] sky130_fd_sc_hd__conb_1
Xpicorv32_1035 VGND VGND VPWR VPWR picorv32_1035/HI mem_addr[0] sky130_fd_sc_hd__conb_1
X_09234_ net1547 net340 net402 VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xpicorv32_1057 VGND VGND VPWR VPWR picorv32_1057/HI pcpi_insn[18] sky130_fd_sc_hd__conb_1
Xpicorv32_1046 VGND VGND VPWR VPWR picorv32_1046/HI pcpi_insn[7] sky130_fd_sc_hd__conb_1
XFILLER_21_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06446_ decoded_imm\[5\] net880 VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__nand2_1
X_09165_ mem_rdata_q\[27\] mem_rdata_q\[26\] _04778_ _04779_ VGND VGND VPWR VPWR _04780_
+ sky130_fd_sc_hd__or4bb_1
Xpicorv32_1079 VGND VGND VPWR VPWR picorv32_1079/HI trace_data[7] sky130_fd_sc_hd__conb_1
XFILLER_22_799 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08116_ _03716_ _03914_ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__nor2_1
X_06377_ net886 net882 net508 VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__mux2_1
XFILLER_119_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_108_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05328_ net14 net597 net587 VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__a21o_1
X_09096_ net976 net550 VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__and2_1
XFILLER_119_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08047_ _03861_ _03862_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__xor2_1
X_05259_ _01801_ _01804_ _01853_ _01854_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__a211o_1
Xhold940 cpuregs\[19\]\[1\] VGND VGND VPWR VPWR net2048 sky130_fd_sc_hd__dlygate4sd3_1
Xhold951 cpuregs\[5\]\[28\] VGND VGND VPWR VPWR net2059 sky130_fd_sc_hd__dlygate4sd3_1
Xhold962 cpuregs\[19\]\[23\] VGND VGND VPWR VPWR net2070 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold973 cpuregs\[19\]\[10\] VGND VGND VPWR VPWR net2081 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold984 cpuregs\[16\]\[26\] VGND VGND VPWR VPWR net2092 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold995 cpuregs\[7\]\[19\] VGND VGND VPWR VPWR net2103 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09998_ clknet_leaf_46_clk _00122_ VGND VGND VPWR VPWR cpuregs\[12\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_110_2093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08949_ net904 _04618_ _04617_ net663 VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__o211a_1
XFILLER_92_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_68_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_68_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_86_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10911_ clknet_leaf_8_clk _00967_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dfxtp_1
XFILLER_29_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10842_ clknet_leaf_111_clk _00901_ VGND VGND VPWR VPWR decoded_rd\[3\] sky130_fd_sc_hd__dfxtp_1
X_10773_ clknet_leaf_61_clk alu_out\[20\] VGND VGND VPWR VPWR alu_out_q\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_2203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_153_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_97_1877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11325_ clknet_leaf_54_clk _01366_ VGND VGND VPWR VPWR cpuregs\[5\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_97_1888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11256_ clknet_leaf_1_clk _01297_ VGND VGND VPWR VPWR cpuregs\[22\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11187_ clknet_leaf_144_clk _01228_ VGND VGND VPWR VPWR cpuregs\[29\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_10207_ clknet_leaf_151_clk _00331_ VGND VGND VPWR VPWR cpuregs\[14\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_94_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10138_ clknet_leaf_121_clk _00262_ VGND VGND VPWR VPWR cpuregs\[21\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10069_ clknet_leaf_77_clk _00193_ VGND VGND VPWR VPWR cpuregs\[13\]\[29\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_128_2387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_2376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_59_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_59_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_85_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_2587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07280_ net1895 net287 net456 VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__mux2_1
X_06300_ instr_srl instr_srli _02734_ VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__nor3_1
X_06231_ net269 net1747 net478 VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__mux2_1
XFILLER_31_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06162_ reg_pc\[10\] _02615_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__xor2_1
Xhold225 cpuregs\[13\]\[29\] VGND VGND VPWR VPWR net1333 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_117_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold203 cpuregs\[28\]\[7\] VGND VGND VPWR VPWR net1311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold214 cpuregs\[30\]\[7\] VGND VGND VPWR VPWR net1322 sky130_fd_sc_hd__dlygate4sd3_1
X_06093_ cpuregs\[0\]\[4\] cpuregs\[1\]\[4\] cpuregs\[2\]\[4\] cpuregs\[3\]\[4\] net954
+ net919 VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__mux4_1
X_05113_ count_instr\[37\] net815 count_cycle\[5\] net622 _01719_ VGND VGND VPWR VPWR
+ _01720_ sky130_fd_sc_hd__a221o_1
Xhold236 cpuregs\[29\]\[30\] VGND VGND VPWR VPWR net1344 sky130_fd_sc_hd__dlygate4sd3_1
Xhold269 cpuregs\[17\]\[30\] VGND VGND VPWR VPWR net1377 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold258 cpuregs\[2\]\[19\] VGND VGND VPWR VPWR net1366 sky130_fd_sc_hd__dlygate4sd3_1
X_09921_ clknet_leaf_10_clk _00050_ VGND VGND VPWR VPWR cpuregs\[11\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold247 cpuregs\[13\]\[10\] VGND VGND VPWR VPWR net1355 sky130_fd_sc_hd__dlygate4sd3_1
X_05044_ net31 net17 net884 VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__mux2_1
XFILLER_131_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout705 net706 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__buf_2
XFILLER_112_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09852_ net281 net1793 net347 VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__mux2_1
XFILLER_86_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout716 cpu_state\[3\] VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__buf_2
Xfanout749 net751 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__clkbuf_4
Xfanout727 _00015_ VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__clkbuf_8
Xfanout738 net748 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__clkbuf_4
X_09783_ net291 net1953 net355 VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__mux2_1
X_08803_ _04482_ _04483_ _04484_ net897 net662 VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__a221o_1
X_06995_ decoded_imm\[25\] net857 VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__nand2_1
X_08734_ net207 net631 _04418_ _04419_ VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__o22a_1
X_05946_ net97 net210 net594 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_622 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05877_ _02094_ net582 _02431_ _02093_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__o22a_1
XFILLER_81_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08665_ cpuregs\[28\]\[10\] cpuregs\[29\]\[10\] cpuregs\[30\]\[10\] cpuregs\[31\]\[10\]
+ net950 net915 VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__mux4_1
XANTENNA_109 net725 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07616_ net1586 net280 net415 VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__mux2_1
X_08596_ net670 _04279_ net889 VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__o21a_1
X_07547_ net288 net2142 net423 VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07478_ net1261 net297 net432 VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_101_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09217_ is_lb_lh_lw_lbu_lhu _02515_ _04796_ _04798_ VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__a22o_1
XFILLER_10_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06429_ cpuregs\[4\]\[4\] cpuregs\[5\]\[4\] net787 VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__mux2_1
XFILLER_147_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09148_ net1186 net501 _04749_ _04773_ VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_79_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09079_ _01097_ _01095_ _01094_ VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__nand3b_1
XFILLER_123_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_2122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_108_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11110_ clknet_leaf_101_clk _00017_ VGND VGND VPWR VPWR cpu_state\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_146_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold781 cpuregs\[24\]\[27\] VGND VGND VPWR VPWR net1889 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_123_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold770 cpuregs\[28\]\[5\] VGND VGND VPWR VPWR net1878 sky130_fd_sc_hd__dlygate4sd3_1
Xhold792 cpuregs\[3\]\[30\] VGND VGND VPWR VPWR net1900 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11041_ clknet_leaf_92_clk _00035_ VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__dfxtp_2
XFILLER_39_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_110_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_72_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10825_ clknet_leaf_98_clk _00884_ VGND VGND VPWR VPWR instr_fence sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_15_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_99_1917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10756_ clknet_leaf_127_clk alu_out\[3\] VGND VGND VPWR VPWR alu_out_q\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10687_ clknet_leaf_144_clk _00779_ VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dfxtp_1
XFILLER_126_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_99_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11308_ clknet_leaf_23_clk _01349_ VGND VGND VPWR VPWR cpuregs\[4\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_11239_ clknet_leaf_47_clk _01280_ VGND VGND VPWR VPWR cpuregs\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_143_2616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05800_ _02110_ _02357_ VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__nor2_1
XFILLER_68_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_143_2627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06780_ _03168_ _03172_ _03195_ VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__a21o_1
XFILLER_55_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05731_ _02135_ _02294_ net692 _02133_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__o211a_1
XFILLER_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08450_ net652 _04183_ _04182_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__a21oi_1
XFILLER_91_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05662_ instr_or instr_ori VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__or2_2
XFILLER_51_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08381_ _04134_ net987 _04133_ VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__and3b_1
X_07401_ net1373 net472 net438 VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__mux2_1
XFILLER_23_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05593_ _02125_ _02160_ _02138_ _02135_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__or4b_1
X_07332_ net1226 net528 net449 VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__mux2_1
XFILLER_32_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07263_ net2076 net535 net455 VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__mux2_1
XFILLER_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09002_ _04670_ _04671_ net682 VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__mux2_1
XFILLER_118_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06214_ _02659_ _02660_ net568 VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__mux2_1
X_07194_ _03563_ _03565_ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__nor2_1
XFILLER_129_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_117_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06145_ reg_out\[7\] alu_out_q\[7\] net840 VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__mux2_1
XFILLER_145_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_105_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06076_ _02543_ _02544_ net674 VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__mux2_1
X_09904_ net1133 VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__clkbuf_1
XFILLER_101_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout524 net525 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__buf_2
Xfanout502 net503 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__clkbuf_4
Xfanout513 net514 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__buf_2
X_05027_ net716 net810 _01601_ _01635_ _01644_ VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__a41o_1
Xfanout557 net558 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__clkbuf_4
Xfanout546 net547 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__clkbuf_4
X_09835_ net529 net1885 net346 VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__mux2_1
Xfanout535 net537 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__clkbuf_2
Xfanout568 _02582_ VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__buf_4
Xfanout579 _02244_ VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__clkbuf_4
X_06978_ cpuregs\[8\]\[24\] cpuregs\[9\]\[24\] cpuregs\[10\]\[24\] cpuregs\[11\]\[24\]
+ net799 net762 VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__mux4_1
X_09766_ net538 net2004 net354 VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__mux2_1
X_09697_ net1814 net241 net368 VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__mux2_1
X_08717_ cpuregs\[28\]\[13\] cpuregs\[29\]\[13\] cpuregs\[30\]\[13\] cpuregs\[31\]\[13\]
+ net948 net913 VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__mux4_1
X_05929_ net885 net171 net596 _01655_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__a211o_1
X_08648_ cpuregs\[4\]\[9\] cpuregs\[5\]\[9\] cpuregs\[6\]\[9\] cpuregs\[7\]\[9\] net941
+ net906 VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__mux4_1
XFILLER_27_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08579_ _04267_ _04271_ _04272_ net889 net895 VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__a221o_1
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10610_ clknet_leaf_89_clk _00734_ VGND VGND VPWR VPWR count_cycle\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_12_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10541_ clknet_leaf_61_clk _00665_ VGND VGND VPWR VPWR reg_pc\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10472_ clknet_leaf_85_clk _00596_ VGND VGND VPWR VPWR count_instr\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_150_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11024_ clknet_leaf_31_clk _01080_ VGND VGND VPWR VPWR cpuregs\[19\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_89_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_125_2335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10808_ clknet_leaf_102_clk _00867_ VGND VGND VPWR VPWR instr_sw sky130_fd_sc_hd__dfxtp_1
XFILLER_14_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10739_ clknet_leaf_52_clk _00830_ VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dfxtp_2
XFILLER_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_680 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput116 net116 VGND VGND VPWR VPWR mem_la_wdata[27] sky130_fd_sc_hd__buf_2
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput105 net105 VGND VGND VPWR VPWR mem_la_wdata[17] sky130_fd_sc_hd__buf_2
Xoutput149 net149 VGND VGND VPWR VPWR mem_wdata[22] sky130_fd_sc_hd__buf_2
Xoutput127 net127 VGND VGND VPWR VPWR mem_la_wdata[8] sky130_fd_sc_hd__buf_2
Xoutput138 net138 VGND VGND VPWR VPWR mem_wdata[12] sky130_fd_sc_hd__buf_2
XFILLER_141_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_608 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07950_ _03771_ _03772_ net687 VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__a21o_1
XFILLER_141_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06901_ cpuregs\[0\]\[21\] cpuregs\[1\]\[21\] cpuregs\[2\]\[21\] cpuregs\[3\]\[21\]
+ net797 net760 VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__mux4_1
X_07881_ reg_pc\[22\] net504 _03719_ net604 VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__a22o_1
XFILLER_110_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09620_ net279 net2031 net375 VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__mux2_1
XFILLER_95_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06832_ _03220_ _03222_ _03219_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__a21oi_1
X_06763_ net735 _03181_ VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__or2_1
X_09551_ net1444 net291 net382 VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_39_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08502_ net87 net1179 net409 VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__mux2_1
X_05714_ _02164_ net581 net583 _02165_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__a2bb2o_1
X_09482_ net1557 net311 net390 VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__mux2_1
X_06694_ net873 _02740_ _03115_ VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__a21o_1
XFILLER_64_794 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05645_ net853 _01565_ _02224_ net854 VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__a22o_1
X_08433_ _01646_ _02734_ _02740_ VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__a21o_1
X_05576_ _02155_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__inv_2
X_08364_ count_cycle\[37\] count_cycle\[38\] _04120_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__and3_1
X_07315_ net1501 net282 net451 VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__mux2_1
X_08295_ net2292 _04079_ net987 VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__o21ai_1
XFILLER_118_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07246_ net1584 net294 net460 VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__mux2_1
X_07177_ net1777 net290 net468 VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__mux2_1
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_133_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_127_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06128_ net529 net1833 net477 VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__mux2_1
X_06059_ cpuregs\[16\]\[2\] cpuregs\[17\]\[2\] cpuregs\[18\]\[2\] cpuregs\[19\]\[2\]
+ net956 net921 VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__mux4_1
Xfanout310 net311 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__clkbuf_2
Xfanout332 net333 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__buf_2
XFILLER_59_511 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout321 net322 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__clkbuf_2
Xfanout343 net344 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__buf_2
Xfanout365 net366 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__clkbuf_8
Xfanout354 _04877_ VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__buf_4
Xfanout376 _04871_ VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__buf_4
X_09818_ net284 net1966 net351 VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__mux2_1
Xfanout387 net388 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__clkbuf_8
XFILLER_87_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout398 net399 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__clkbuf_8
XFILLER_47_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09749_ net295 net2104 net360 VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_2043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_2254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 mem_rdata[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_4
XFILLER_128_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput29 mem_rdata[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
XFILLER_11_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10524_ clknet_leaf_128_clk _00648_ VGND VGND VPWR VPWR reg_pc\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10455_ clknet_leaf_23_clk _00579_ VGND VGND VPWR VPWR cpuregs\[17\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10386_ clknet_leaf_49_clk _00510_ VGND VGND VPWR VPWR cpuregs\[25\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_111_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_77_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11007_ clknet_leaf_120_clk _01063_ VGND VGND VPWR VPWR cpuregs\[19\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_65_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05430_ reg_pc\[29\] decoded_imm\[29\] VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__and2_1
XFILLER_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_138_2537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05361_ reg_pc\[23\] decoded_imm\[23\] _01927_ _01947_ _01948_ VGND VGND VPWR VPWR
+ _01949_ sky130_fd_sc_hd__a221o_1
XFILLER_20_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07100_ _03502_ _03503_ net655 VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__mux2_1
XFILLER_119_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08080_ _03713_ _03887_ net685 VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__o21a_1
X_05292_ count_instr\[50\] net817 net826 count_cycle\[50\] VGND VGND VPWR VPWR _01886_
+ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_151_2748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07031_ cpuregs\[28\]\[26\] cpuregs\[29\]\[26\] cpuregs\[30\]\[26\] cpuregs\[31\]\[26\]
+ net803 net766 VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__mux4_1
XFILLER_115_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_114_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_88_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_143_Right_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08982_ cpuregs\[0\]\[27\] cpuregs\[1\]\[27\] cpuregs\[2\]\[27\] cpuregs\[3\]\[27\]
+ net969 net934 VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_71_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07933_ _03756_ _03757_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__nor2_1
X_07864_ reg_pc\[14\] net504 _03710_ net604 VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_71_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06815_ cpuregs\[12\]\[18\] cpuregs\[13\]\[18\] cpuregs\[14\]\[18\] cpuregs\[15\]\[18\]
+ net793 net755 VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__mux4_1
XFILLER_83_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09603_ net527 net1594 net374 VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__mux2_1
XFILLER_84_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07795_ count_instr\[48\] _03667_ count_instr\[49\] VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__a21o_1
X_06746_ decoded_imm\[14\] net872 _03138_ VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__nand3_1
XFILLER_71_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09534_ net1462 net539 net381 VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__mux2_1
XFILLER_37_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09465_ net239 net2204 net395 VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__mux2_1
X_06677_ net174 net507 VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__or2_1
XFILLER_36_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08416_ count_cycle\[55\] count_cycle\[56\] count_cycle\[57\] _04151_ VGND VGND VPWR
+ VPWR _04157_ sky130_fd_sc_hd__and4_1
X_05628_ net210 net870 VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__and2b_1
XFILLER_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09396_ net835 decoded_imm_j\[2\] _04825_ mem_rdata_q\[9\] net551 VGND VGND VPWR
+ VPWR _04862_ sky130_fd_sc_hd__a221o_1
XFILLER_138_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05559_ _02138_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__inv_2
X_08347_ count_cycle\[31\] _04110_ count_cycle\[32\] VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__a21o_1
XFILLER_11_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08278_ count_cycle\[4\] count_cycle\[5\] count_cycle\[6\] _04065_ VGND VGND VPWR
+ VPWR _04070_ sky130_fd_sc_hd__and4_2
XFILLER_153_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07229_ net1611 net540 net458 VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__mux2_1
XFILLER_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10240_ clknet_leaf_2_clk _00364_ VGND VGND VPWR VPWR cpuregs\[27\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_10171_ clknet_leaf_128_clk _00295_ VGND VGND VPWR VPWR cpuregs\[9\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_87_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_89_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10507_ clknet_leaf_84_clk _00631_ VGND VGND VPWR VPWR count_instr\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_2456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11487_ clknet_leaf_21_clk _01525_ VGND VGND VPWR VPWR cpuregs\[10\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10438_ clknet_leaf_28_clk _00562_ VGND VGND VPWR VPWR cpuregs\[17\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10369_ clknet_leaf_151_clk _00493_ VGND VGND VPWR VPWR cpuregs\[25\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04930_ net854 VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_53_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_0_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07580_ net2187 net290 net420 VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__mux2_1
XFILLER_80_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06600_ cpuregs\[24\]\[10\] cpuregs\[25\]\[10\] cpuregs\[26\]\[10\] cpuregs\[27\]\[10\]
+ net782 net746 VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_0_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06531_ decoded_imm\[8\] net877 VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__or2_1
XFILLER_18_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09250_ net1317 net267 net404 VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__mux2_1
XFILLER_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08201_ _03722_ _03723_ _03981_ VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__and3_1
X_06462_ net645 _02891_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__or2_1
X_05413_ _01965_ _01950_ _01953_ _01996_ VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__and4b_1
X_09181_ _04792_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__inv_2
X_06393_ net733 _02824_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__and2_1
XFILLER_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_147_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_146_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08132_ _03718_ _03936_ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__nand2_1
X_05344_ count_cycle\[22\] net618 VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__or2_1
XFILLER_134_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05275_ reg_pc\[17\] decoded_imm\[17\] VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__or2_1
X_08063_ net836 _03874_ _03875_ _03877_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__a22o_1
X_07014_ _03415_ _03416_ net656 VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__mux2_1
XFILLER_146_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_135_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_703 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08965_ _04632_ _04633_ net681 VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__mux2_1
XFILLER_130_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07916_ _03699_ _03732_ _01618_ VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__o21ai_1
X_08896_ net217 net632 _04571_ _04572_ VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__o22a_1
XFILLER_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07847_ _02602_ reg_next_pc\[6\] net570 VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_104_2002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_826 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07778_ net2296 _03657_ _03659_ VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__a21oi_1
XFILLER_56_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09517_ net1403 net295 net387 VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__mux2_1
X_06729_ cpuregs\[20\]\[15\] cpuregs\[21\]\[15\] cpuregs\[22\]\[15\] cpuregs\[23\]\[15\]
+ net795 net758 VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__mux4_1
XFILLER_71_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09448_ net313 net1920 net393 VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__mux2_1
XFILLER_25_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09379_ net833 decoded_imm_j\[9\] _04826_ mem_rdata_q\[29\] net550 VGND VGND VPWR
+ VPWR _04852_ sky130_fd_sc_hd__a221o_1
XFILLER_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11410_ clknet_leaf_116_clk _01448_ VGND VGND VPWR VPWR cpuregs\[8\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_789 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11341_ clknet_leaf_102_clk _00024_ VGND VGND VPWR VPWR mem_wordsize\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_138_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_115_2164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_141_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11272_ clknet_leaf_66_clk _01313_ VGND VGND VPWR VPWR cpuregs\[22\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_115_2175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10223_ clknet_leaf_47_clk _00347_ VGND VGND VPWR VPWR cpuregs\[14\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_133_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10154_ clknet_leaf_34_clk _00278_ VGND VGND VPWR VPWR cpuregs\[21\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_94_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_874 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold7 cpuregs\[0\]\[16\] VGND VGND VPWR VPWR net1115 sky130_fd_sc_hd__dlygate4sd3_1
X_10085_ clknet_leaf_8_clk _00209_ VGND VGND VPWR VPWR cpuregs\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_90_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_889 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_399 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_678 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10987_ clknet_leaf_7_clk _01043_ VGND VGND VPWR VPWR cpuregs\[18\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_128_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_143_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_128_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_117_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold407 cpuregs\[26\]\[12\] VGND VGND VPWR VPWR net1515 sky130_fd_sc_hd__dlygate4sd3_1
Xhold418 cpuregs\[15\]\[3\] VGND VGND VPWR VPWR net1526 sky130_fd_sc_hd__dlygate4sd3_1
Xhold429 cpuregs\[13\]\[26\] VGND VGND VPWR VPWR net1537 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05060_ count_instr\[33\] net815 net622 _01670_ VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_55_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout909 net910 VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__clkbuf_4
XFILLER_112_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_85_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1107 cpuregs\[19\]\[25\] VGND VGND VPWR VPWR net2215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1129 count_cycle\[31\] VGND VGND VPWR VPWR net2237 sky130_fd_sc_hd__dlygate4sd3_1
X_08750_ net893 _04433_ net665 VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__a21o_1
Xhold1118 latched_is_lb VGND VGND VPWR VPWR net2226 sky130_fd_sc_hd__dlygate4sd3_1
X_05962_ latched_branch latched_store VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_146_2669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05893_ net542 _02445_ _02441_ VGND VGND VPWR VPWR alu_out\[27\] sky130_fd_sc_hd__o21ai_1
X_04913_ net829 VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__inv_2
X_07701_ net2306 _03608_ _03610_ VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__a21oi_1
X_08681_ cpuregs\[12\]\[11\] cpuregs\[13\]\[11\] cpuregs\[14\]\[11\] cpuregs\[15\]\[11\]
+ net941 net906 VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__mux4_1
XFILLER_93_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07632_ _02591_ net1601 net411 VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__mux2_1
X_09302_ net1166 net116 net484 VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__mux2_1
XFILLER_81_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07563_ net1627 net537 net419 VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1014 VGND VGND VPWR VPWR picorv32_1014/HI eoi[11] sky130_fd_sc_hd__conb_1
Xpicorv32_1025 VGND VGND VPWR VPWR picorv32_1025/HI eoi[22] sky130_fd_sc_hd__conb_1
XFILLER_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_66_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1003 VGND VGND VPWR VPWR picorv32_1003/HI eoi[0] sky130_fd_sc_hd__conb_1
X_07494_ _03564_ _03575_ VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__and2_2
X_06514_ net495 _02871_ _02939_ _02938_ net606 VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__a32o_1
Xpicorv32_1047 VGND VGND VPWR VPWR picorv32_1047/HI pcpi_insn[8] sky130_fd_sc_hd__conb_1
X_09233_ net1303 net471 net402 VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1036 VGND VGND VPWR VPWR picorv32_1036/HI mem_addr[1] sky130_fd_sc_hd__conb_1
Xpicorv32_1058 VGND VGND VPWR VPWR picorv32_1058/HI pcpi_insn[19] sky130_fd_sc_hd__conb_1
XFILLER_21_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06445_ net2029 net303 _02875_ VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__a21o_1
X_09164_ mem_rdata_q\[25\] mem_rdata_q\[24\] VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__nor2_1
Xpicorv32_1069 VGND VGND VPWR VPWR picorv32_1069/HI pcpi_insn[30] sky130_fd_sc_hd__conb_1
XFILLER_135_603 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08115_ net685 _03924_ _03925_ VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__or3_1
X_06376_ _02808_ VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__inv_2
X_05327_ _01915_ _01916_ _01917_ net714 VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__o211a_1
X_09095_ decoder_pseudo_trigger net849 VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__nand2b_1
XFILLER_123_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08046_ _03847_ _03853_ _03846_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__a21bo_1
X_05258_ _01808_ _01819_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__or2_1
Xhold930 cpuregs\[8\]\[7\] VGND VGND VPWR VPWR net2038 sky130_fd_sc_hd__dlygate4sd3_1
Xhold941 cpuregs\[7\]\[21\] VGND VGND VPWR VPWR net2049 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold952 cpuregs\[22\]\[14\] VGND VGND VPWR VPWR net2060 sky130_fd_sc_hd__dlygate4sd3_1
X_05189_ reg_pc\[11\] decoded_imm\[11\] VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__or2_1
XFILLER_1_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold963 cpuregs\[8\]\[3\] VGND VGND VPWR VPWR net2071 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold996 cpuregs\[6\]\[16\] VGND VGND VPWR VPWR net2104 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold974 cpuregs\[8\]\[6\] VGND VGND VPWR VPWR net2082 sky130_fd_sc_hd__dlygate4sd3_1
Xhold985 cpuregs\[27\]\[0\] VGND VGND VPWR VPWR net2093 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_135_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_130_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09997_ clknet_leaf_43_clk _00121_ VGND VGND VPWR VPWR cpuregs\[12\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_110_2094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_131_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08948_ _04609_ _04610_ net904 VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__mux2_1
X_08879_ decoded_imm\[21\] net598 net627 VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_86_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_57_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_84_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10910_ clknet_leaf_8_clk _00966_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dfxtp_1
XFILLER_45_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_53_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10841_ clknet_leaf_112_clk _00900_ VGND VGND VPWR VPWR decoded_rd\[2\] sky130_fd_sc_hd__dfxtp_1
X_10772_ clknet_leaf_60_clk alu_out\[19\] VGND VGND VPWR VPWR alu_out_q\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_117_2204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_2415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11324_ clknet_leaf_16_clk _01365_ VGND VGND VPWR VPWR cpuregs\[5\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_10_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11255_ clknet_leaf_13_clk _01296_ VGND VGND VPWR VPWR cpuregs\[22\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10206_ clknet_leaf_146_clk _00330_ VGND VGND VPWR VPWR cpuregs\[14\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_11186_ clknet_leaf_141_clk _01227_ VGND VGND VPWR VPWR cpuregs\[29\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10137_ clknet_leaf_120_clk _00261_ VGND VGND VPWR VPWR cpuregs\[21\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_10068_ clknet_leaf_71_clk _00192_ VGND VGND VPWR VPWR cpuregs\[13\]\[28\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_128_2377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_2588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_48_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06230_ _02672_ _02673_ net567 VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__mux2_2
XFILLER_117_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06161_ reg_out\[10\] alu_out_q\[10\] net840 VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__mux2_1
Xhold215 cpuregs\[21\]\[26\] VGND VGND VPWR VPWR net1323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold226 cpuregs\[21\]\[17\] VGND VGND VPWR VPWR net1334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold204 cpuregs\[31\]\[15\] VGND VGND VPWR VPWR net1312 sky130_fd_sc_hd__dlygate4sd3_1
X_05112_ count_instr\[5\] net819 count_cycle\[37\] net824 VGND VGND VPWR VPWR _01719_
+ sky130_fd_sc_hd__a22o_1
XFILLER_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06092_ cpuregs\[4\]\[4\] cpuregs\[5\]\[4\] cpuregs\[6\]\[4\] cpuregs\[7\]\[4\] net954
+ net919 VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__mux4_1
XFILLER_144_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold248 cpuregs\[12\]\[24\] VGND VGND VPWR VPWR net1356 sky130_fd_sc_hd__dlygate4sd3_1
Xhold259 cpuregs\[4\]\[31\] VGND VGND VPWR VPWR net1367 sky130_fd_sc_hd__dlygate4sd3_1
X_05043_ _01553_ net695 _01653_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__o21a_2
Xhold237 cpuregs\[30\]\[12\] VGND VGND VPWR VPWR net1345 sky130_fd_sc_hd__dlygate4sd3_1
X_09920_ clknet_leaf_4_clk _00049_ VGND VGND VPWR VPWR cpuregs\[11\]\[12\] sky130_fd_sc_hd__dfxtp_1
Xfanout706 net710 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__buf_2
XFILLER_113_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09851_ net283 net2206 net347 VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__mux2_1
Xfanout728 net730 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__buf_4
Xfanout717 cpu_state\[2\] VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__buf_2
Xfanout739 net741 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09782_ net295 net1679 net356 VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__mux2_1
X_06994_ decoded_imm\[25\] net857 VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__nor2_1
X_08802_ _04476_ _04477_ net677 VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05945_ net696 net844 net209 net593 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__a22o_1
X_08733_ decoded_imm\[13\] net600 net626 VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_68_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05876_ _02094_ net576 net586 VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__a21oi_1
XFILLER_54_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08664_ cpuregs\[16\]\[10\] cpuregs\[17\]\[10\] cpuregs\[18\]\[10\] cpuregs\[19\]\[10\]
+ net950 net915 VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__mux4_1
XFILLER_26_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07615_ net1782 net285 net415 VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__mux2_1
X_08595_ cpuregs\[8\]\[6\] cpuregs\[9\]\[6\] cpuregs\[10\]\[6\] cpuregs\[11\]\[6\]
+ net943 net908 VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__mux4_1
X_07546_ net291 net2112 net423 VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07477_ net1442 net302 net431 VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__mux2_1
X_09216_ _01100_ _04797_ net332 VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06428_ cpuregs\[7\]\[4\] net785 net749 VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__a21bo_1
XFILLER_108_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09147_ net976 is_alu_reg_reg _04772_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__and3_2
X_06359_ cpuregs\[16\]\[2\] cpuregs\[17\]\[2\] cpuregs\[18\]\[2\] cpuregs\[19\]\[2\]
+ net790 net753 VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__mux4_1
XFILLER_107_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09078_ net2300 net26 net614 VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_112_2123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08029_ decoded_imm_j\[13\] _03709_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__nand2_1
XFILLER_150_447 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold782 cpuregs\[5\]\[22\] VGND VGND VPWR VPWR net1890 sky130_fd_sc_hd__dlygate4sd3_1
Xhold760 cpuregs\[14\]\[18\] VGND VGND VPWR VPWR net1868 sky130_fd_sc_hd__dlygate4sd3_1
Xhold771 cpuregs\[17\]\[31\] VGND VGND VPWR VPWR net1879 sky130_fd_sc_hd__dlygate4sd3_1
Xhold793 cpuregs\[28\]\[16\] VGND VGND VPWR VPWR net1901 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_92_1797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11040_ clknet_leaf_92_clk _00034_ VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__dfxtp_2
XFILLER_89_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10824_ clknet_leaf_87_clk _00883_ VGND VGND VPWR VPWR instr_rdinstr sky130_fd_sc_hd__dfxtp_1
XFILLER_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10755_ clknet_leaf_126_clk alu_out\[2\] VGND VGND VPWR VPWR alu_out_q\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10686_ clknet_leaf_124_clk _00778_ VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dfxtp_1
XFILLER_5_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11307_ clknet_leaf_74_clk _01348_ VGND VGND VPWR VPWR cpuregs\[4\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_126_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11238_ clknet_leaf_50_clk _01279_ VGND VGND VPWR VPWR cpuregs\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_11169_ clknet_leaf_37_clk _01210_ VGND VGND VPWR VPWR cpuregs\[23\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_96_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_143_2617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05730_ _02137_ net581 _02300_ _02136_ VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__o22a_1
X_05661_ _02046_ _02176_ _02237_ _02240_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__o22a_1
XFILLER_36_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08380_ count_cycle\[43\] count_cycle\[44\] _04130_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__and3_1
X_07400_ net1386 net474 net438 VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_63_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05592_ _02170_ _02171_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__nand2b_1
X_07331_ net1237 net530 net446 VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07262_ net1558 net538 net455 VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__mux2_1
X_09001_ _04663_ _04664_ _04668_ _04669_ net682 net667 VGND VGND VPWR VPWR _04672_
+ sky130_fd_sc_hd__mux4_1
X_06213_ reg_pc\[20\] _02656_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__xor2_1
X_07193_ _02579_ _03564_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__nand2_4
X_06144_ _02604_ net1655 net476 VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__mux2_1
XFILLER_145_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_145_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06075_ cpuregs\[8\]\[3\] cpuregs\[9\]\[3\] cpuregs\[10\]\[3\] cpuregs\[11\]\[3\]
+ net953 net918 VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__mux4_1
X_09903_ net1144 VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__clkbuf_1
Xfanout514 net515 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__buf_2
X_05026_ net601 _01643_ _01636_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__a21boi_1
Xfanout503 _03698_ VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout547 _01631_ VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__buf_4
XFILLER_98_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout525 net526 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__clkbuf_4
Xfanout536 net537 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__clkbuf_2
X_09834_ net531 net1740 net346 VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__mux2_1
XFILLER_86_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout569 net571 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__clkbuf_4
Xfanout558 _03586_ VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__clkbuf_4
X_06977_ cpuregs\[12\]\[24\] cpuregs\[13\]\[24\] cpuregs\[14\]\[24\] cpuregs\[15\]\[24\]
+ net804 net767 VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__mux4_1
XFILLER_101_878 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09765_ _02580_ _04873_ VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__or2_2
X_09696_ net1289 net245 net368 VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__mux2_1
X_05928_ net884 _01553_ net596 _01655_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__a211o_1
XFILLER_67_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08716_ cpuregs\[24\]\[13\] cpuregs\[25\]\[13\] cpuregs\[26\]\[13\] cpuregs\[27\]\[13\]
+ net949 net914 VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__mux4_1
X_05859_ _02049_ _02111_ _02414_ _02047_ VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__a211o_1
XFILLER_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08647_ cpuregs\[24\]\[9\] cpuregs\[25\]\[9\] cpuregs\[26\]\[9\] cpuregs\[27\]\[9\]
+ net942 net907 VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__mux4_1
XFILLER_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08578_ _04260_ _04261_ net670 VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__mux2_1
XFILLER_42_648 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07529_ net540 net2033 net422 VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__mux2_1
X_10540_ clknet_leaf_60_clk _00664_ VGND VGND VPWR VPWR reg_pc\[20\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_12_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10471_ clknet_leaf_104_clk _00595_ VGND VGND VPWR VPWR count_instr\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold590 cpuregs\[7\]\[13\] VGND VGND VPWR VPWR net1698 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_150_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11023_ clknet_leaf_28_clk _01079_ VGND VGND VPWR VPWR cpuregs\[19\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_125_2325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_77_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_65_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_125_2336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_73_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_103_1977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10807_ clknet_leaf_96_clk _00866_ VGND VGND VPWR VPWR instr_andi sky130_fd_sc_hd__dfxtp_1
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10738_ clknet_leaf_54_clk _00829_ VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dfxtp_4
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10669_ clknet_leaf_61_clk _04894_ VGND VGND VPWR VPWR reg_out\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_153_2790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_127_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput106 net106 VGND VGND VPWR VPWR mem_la_wdata[18] sky130_fd_sc_hd__buf_2
XFILLER_127_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_126_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput117 net117 VGND VGND VPWR VPWR mem_la_wdata[28] sky130_fd_sc_hd__buf_2
Xoutput139 net139 VGND VGND VPWR VPWR mem_wdata[13] sky130_fd_sc_hd__buf_2
Xoutput128 net128 VGND VGND VPWR VPWR mem_la_wdata[9] sky130_fd_sc_hd__buf_2
X_06900_ cpuregs\[4\]\[21\] cpuregs\[5\]\[21\] cpuregs\[6\]\[21\] cpuregs\[7\]\[21\]
+ net797 net760 VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__mux4_1
X_07880_ _02667_ reg_next_pc\[22\] net573 VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__mux2_2
XFILLER_96_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06831_ _03244_ _03246_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__nor2_1
XFILLER_56_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06762_ cpuregs\[16\]\[16\] cpuregs\[17\]\[16\] cpuregs\[18\]\[16\] cpuregs\[19\]\[16\]
+ net799 net762 VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__mux4_1
X_09550_ net1635 net296 net382 VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__mux2_1
XFILLER_95_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_83_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_39_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08501_ net85 net1182 net409 VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__mux2_1
X_09481_ net1713 net314 net389 VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__mux2_1
X_05713_ _02166_ net578 VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_19_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08432_ net2238 _04165_ _04166_ VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__o21ba_1
X_06693_ net524 _03096_ _03100_ _03114_ net306 VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__o311a_1
XFILLER_51_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05644_ net223 _02082_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__nor2_1
X_05575_ _02153_ _02154_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__nor2_1
X_08363_ count_cycle\[37\] _04120_ count_cycle\[38\] VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__a21o_1
XFILLER_11_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07314_ net1857 net285 net451 VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__mux2_1
X_08294_ count_cycle\[10\] count_cycle\[11\] count_cycle\[12\] _04075_ VGND VGND VPWR
+ VPWR _04080_ sky130_fd_sc_hd__and4_1
X_07245_ net1342 net297 net460 VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__mux2_1
X_07176_ net1565 net293 net468 VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06127_ _02589_ _02590_ net566 VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__mux2_1
XFILLER_105_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06058_ cpuregs\[20\]\[2\] cpuregs\[21\]\[2\] cpuregs\[22\]\[2\] cpuregs\[23\]\[2\]
+ net956 net921 VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__mux4_1
Xfanout300 net302 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout311 _02637_ VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__clkbuf_2
Xfanout322 _02626_ VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__buf_2
X_05009_ net835 net849 VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__nand2_1
Xfanout355 net356 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkbuf_8
XFILLER_87_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout333 _02514_ VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__clkbuf_4
Xfanout344 _01848_ VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__buf_2
XFILLER_59_523 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout366 _04874_ VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__buf_4
XFILLER_143_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout388 _04868_ VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__buf_4
Xfanout399 net400 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkbuf_8
X_09817_ net289 net2124 net351 VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__mux2_1
Xfanout377 net380 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_107_2044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09748_ net299 net2216 net357 VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__mux2_1
XFILLER_46_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09679_ net1297 net316 net365 VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_6_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_2255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10523_ clknet_leaf_128_clk _00647_ VGND VGND VPWR VPWR reg_pc\[3\] sky130_fd_sc_hd__dfxtp_1
Xinput19 mem_rdata[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_2
X_10454_ clknet_leaf_63_clk _00578_ VGND VGND VPWR VPWR cpuregs\[17\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_10385_ clknet_leaf_66_clk _00509_ VGND VGND VPWR VPWR cpuregs\[25\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_117_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11006_ clknet_leaf_138_clk _01062_ VGND VGND VPWR VPWR cpuregs\[19\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_93_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_138_2538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05360_ reg_pc\[22\] decoded_imm\[22\] _01936_ VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__and3_1
XFILLER_60_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05291_ net10 net597 net587 VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_151_2749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07030_ cpuregs\[8\]\[26\] cpuregs\[9\]\[26\] cpuregs\[10\]\[26\] cpuregs\[11\]\[26\]
+ net803 net766 VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__mux4_1
XFILLER_127_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08981_ net684 _04652_ VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__or2_1
XFILLER_69_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07932_ decoded_imm_j\[5\] _03701_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__and2_1
X_07863_ _02635_ reg_next_pc\[14\] net572 VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_71_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06814_ cpuregs\[16\]\[18\] cpuregs\[17\]\[18\] cpuregs\[18\]\[18\] cpuregs\[19\]\[18\]
+ net792 net755 VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__mux4_1
XFILLER_56_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09602_ net530 net1585 net374 VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__mux2_1
X_07794_ net2265 _03667_ _03669_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__a21oi_1
X_09533_ latched_rd\[1\] latched_rd\[0\] _03582_ VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__and3_1
X_06745_ _03064_ _03091_ _03090_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__o21a_1
X_09464_ net243 net2125 net395 VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__mux2_1
X_06676_ net876 net507 net488 _03097_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__o211a_1
X_08415_ count_cycle\[57\] _04155_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__or2_1
X_05627_ net211 net868 VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__and2b_1
X_09395_ mem_rdata_q\[22\] _04794_ VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__and2_1
XFILLER_40_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08346_ net2237 _04110_ _04112_ VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__a21oi_1
XFILLER_138_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05558_ _02136_ _02137_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__and2b_1
XFILLER_125_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05489_ net865 net213 VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_22_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08277_ _04069_ net982 _04068_ VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__and3b_1
XFILLER_153_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07228_ _03559_ _03567_ VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__nor2_4
XFILLER_146_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07159_ net1641 net540 net466 VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__mux2_1
XFILLER_3_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10170_ clknet_leaf_117_clk _00294_ VGND VGND VPWR VPWR cpuregs\[9\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_89_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10506_ clknet_leaf_84_clk _00630_ VGND VGND VPWR VPWR count_instr\[49\] sky130_fd_sc_hd__dfxtp_1
X_11486_ clknet_leaf_9_clk _01524_ VGND VGND VPWR VPWR cpuregs\[10\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_133_2457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10437_ clknet_leaf_10_clk _00561_ VGND VGND VPWR VPWR cpuregs\[17\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_124_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10368_ clknet_leaf_150_clk _00492_ VGND VGND VPWR VPWR cpuregs\[25\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_40_7 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10299_ clknet_leaf_125_clk _00423_ VGND VGND VPWR VPWR cpuregs\[26\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_53_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_69_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_81_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06530_ net878 net303 _02957_ VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__a21o_1
X_06461_ cpuregs\[4\]\[5\] cpuregs\[5\]\[5\] cpuregs\[6\]\[5\] cpuregs\[7\]\[5\] net775
+ net739 VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__mux4_1
XFILLER_22_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08200_ _04002_ _04003_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__nand2_1
X_05412_ _01976_ _01987_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__nor2_1
XFILLER_33_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_147_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_78_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09180_ mem_rdata_q\[4\] mem_rdata_q\[5\] mem_rdata_q\[6\] _04791_ VGND VGND VPWR
+ VPWR _04792_ sky130_fd_sc_hd__or4b_1
X_06392_ cpuregs\[20\]\[3\] cpuregs\[21\]\[3\] cpuregs\[22\]\[3\] cpuregs\[23\]\[3\]
+ net789 net752 VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__mux4_1
X_08131_ _03939_ _03940_ net991 VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__o21a_1
X_05343_ count_instr\[22\] net822 net623 _01932_ VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__a211o_1
XFILLER_146_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08062_ net836 _03876_ VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__nor2_1
X_05274_ _01864_ _01868_ _01869_ VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__or3_1
X_07013_ _03417_ _03418_ net656 VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__mux2_1
XFILLER_128_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_715 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08964_ net681 _04629_ net892 VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__o21a_1
XFILLER_103_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_459 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_88_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_87_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07915_ _03740_ _03741_ VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__nor2_1
XFILLER_130_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_111_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08895_ decoded_imm\[22\] net598 net627 VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__a21o_1
XFILLER_69_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07846_ reg_pc\[5\] net502 _03701_ net602 VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_104_2003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_838 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07777_ count_instr\[42\] _03657_ net986 VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__o21ai_1
X_04989_ net718 net608 net978 VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__o21ai_1
XFILLER_83_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06728_ cpuregs\[0\]\[15\] cpuregs\[1\]\[15\] cpuregs\[2\]\[15\] cpuregs\[3\]\[15\]
+ net782 net746 VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__mux4_1
X_09516_ net1312 net301 net385 VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__mux2_1
XFILLER_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_84_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09447_ net316 net1659 net393 VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__mux2_1
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_96_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06659_ cpuregs\[16\]\[12\] cpuregs\[17\]\[12\] cpuregs\[18\]\[12\] cpuregs\[19\]\[12\]
+ net778 net742 VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__mux4_1
XFILLER_9_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09378_ net2359 net556 _04851_ VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__o21a_1
XFILLER_138_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08329_ count_cycle\[25\] _04100_ net992 VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__a21boi_1
X_11340_ clknet_leaf_24_clk _01381_ VGND VGND VPWR VPWR cpuregs\[5\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_11271_ clknet_leaf_45_clk _01312_ VGND VGND VPWR VPWR cpuregs\[22\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_115_2176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_106_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10222_ clknet_leaf_41_clk _00346_ VGND VGND VPWR VPWR cpuregs\[14\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10153_ clknet_leaf_28_clk _00277_ VGND VGND VPWR VPWR cpuregs\[21\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10084_ clknet_leaf_6_clk _00208_ VGND VGND VPWR VPWR cpuregs\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold8 cpuregs\[0\]\[2\] VGND VGND VPWR VPWR net1116 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10986_ clknet_leaf_6_clk _01042_ VGND VGND VPWR VPWR cpuregs\[18\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_130_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold408 cpuregs\[12\]\[23\] VGND VGND VPWR VPWR net1516 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11469_ clknet_leaf_77_clk _01507_ VGND VGND VPWR VPWR cpuregs\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_143_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold419 cpuregs\[21\]\[4\] VGND VGND VPWR VPWR net1527 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_140_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_512 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05961_ net227 net595 _02482_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__a21o_1
Xhold1119 cpuregs\[16\]\[15\] VGND VGND VPWR VPWR net2227 sky130_fd_sc_hd__dlygate4sd3_1
X_07700_ count_instr\[14\] _03608_ net987 VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__o21ai_1
Xhold1108 cpuregs\[6\]\[15\] VGND VGND VPWR VPWR net2216 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_38_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05892_ _02104_ _02444_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__xnor2_1
XFILLER_66_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08680_ net204 net631 _04367_ _04368_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__o22a_1
XFILLER_39_857 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07631_ net531 net1582 net411 VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__mux2_1
XFILLER_53_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07562_ net1305 net540 net418 VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__mux2_1
X_09301_ net1176 net115 net484 VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__mux2_1
XFILLER_62_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06513_ net882 net506 net488 _02940_ VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__o211a_1
Xpicorv32_1015 VGND VGND VPWR VPWR picorv32_1015/HI eoi[12] sky130_fd_sc_hd__conb_1
Xpicorv32_1004 VGND VGND VPWR VPWR picorv32_1004/HI eoi[1] sky130_fd_sc_hd__conb_1
X_07493_ net1507 net237 net432 VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1026 VGND VGND VPWR VPWR picorv32_1026/HI eoi[23] sky130_fd_sc_hd__conb_1
Xpicorv32_1037 VGND VGND VPWR VPWR picorv32_1037/HI mem_la_addr[0] sky130_fd_sc_hd__conb_1
Xpicorv32_1048 VGND VGND VPWR VPWR picorv32_1048/HI pcpi_insn[9] sky130_fd_sc_hd__conb_1
Xpicorv32_1059 VGND VGND VPWR VPWR picorv32_1059/HI pcpi_insn[20] sky130_fd_sc_hd__conb_1
X_09232_ net1738 net473 net402 VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__mux2_1
X_06444_ net304 _02864_ _02874_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__and3_1
X_09163_ mem_rdata_q\[31\] mem_rdata_q\[30\] net553 _04777_ VGND VGND VPWR VPWR _04778_
+ sky130_fd_sc_hd__and4_1
X_06375_ _02778_ _02781_ _02804_ _02806_ VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__o211a_1
X_05326_ _01915_ _01916_ VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__nand2_1
X_08114_ _03910_ _03921_ _03923_ VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__and3_1
XFILLER_135_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09094_ decoder_pseudo_trigger net849 VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__and2b_1
XFILLER_135_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold920 cpuregs\[27\]\[16\] VGND VGND VPWR VPWR net2028 sky130_fd_sc_hd__dlygate4sd3_1
Xhold931 cpuregs\[5\]\[17\] VGND VGND VPWR VPWR net2039 sky130_fd_sc_hd__dlygate4sd3_1
X_08045_ _03859_ _03860_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__and2_1
X_05257_ _01830_ _01840_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__nand2b_1
Xhold953 cpuregs\[9\]\[28\] VGND VGND VPWR VPWR net2061 sky130_fd_sc_hd__dlygate4sd3_1
Xhold964 cpuregs\[9\]\[31\] VGND VGND VPWR VPWR net2072 sky130_fd_sc_hd__dlygate4sd3_1
Xhold942 cpuregs\[7\]\[15\] VGND VGND VPWR VPWR net2050 sky130_fd_sc_hd__dlygate4sd3_1
X_05188_ reg_pc\[11\] decoded_imm\[11\] VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__nand2_1
XFILLER_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold975 cpuregs\[16\]\[28\] VGND VGND VPWR VPWR net2083 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold986 cpuregs\[16\]\[10\] VGND VGND VPWR VPWR net2094 sky130_fd_sc_hd__dlygate4sd3_1
Xhold997 cpuregs\[6\]\[2\] VGND VGND VPWR VPWR net2105 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_135_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09996_ clknet_leaf_35_clk _00120_ VGND VGND VPWR VPWR cpuregs\[12\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_110_2084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08947_ _04615_ _04619_ _04620_ net894 net898 VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_110_2095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_76_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08878_ _04554_ _04555_ net480 _04552_ VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__o211a_1
XFILLER_151_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07829_ _03691_ net1000 _03690_ VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_86_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10840_ clknet_leaf_111_clk _00899_ VGND VGND VPWR VPWR decoded_rd\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_44_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10771_ clknet_leaf_59_clk alu_out\[18\] VGND VGND VPWR VPWR alu_out_q\[18\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_145_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_145_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_44_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_2205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_100_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_130_2416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11323_ clknet_leaf_29_clk _01364_ VGND VGND VPWR VPWR cpuregs\[5\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_125_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11254_ clknet_leaf_153_clk _01295_ VGND VGND VPWR VPWR cpuregs\[22\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_134_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10205_ clknet_leaf_139_clk _00329_ VGND VGND VPWR VPWR cpuregs\[14\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11185_ clknet_leaf_122_clk _01226_ VGND VGND VPWR VPWR cpuregs\[29\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10136_ clknet_leaf_138_clk _00260_ VGND VGND VPWR VPWR cpuregs\[21\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_10067_ clknet_leaf_69_clk _00191_ VGND VGND VPWR VPWR cpuregs\[13\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_128_2378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_85_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_90_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_141_2589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_90_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10969_ clknet_leaf_131_clk _01025_ VGND VGND VPWR VPWR decoded_imm\[5\] sky130_fd_sc_hd__dfxtp_2
XFILLER_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_136_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_136_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_149_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06160_ net328 net1497 net476 VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__mux2_1
XFILLER_117_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_116_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold205 cpuregs\[21\]\[18\] VGND VGND VPWR VPWR net1313 sky130_fd_sc_hd__dlygate4sd3_1
Xhold216 mem_rdata_q\[11\] VGND VGND VPWR VPWR net1324 sky130_fd_sc_hd__dlygate4sd3_1
X_06091_ net2322 _01624_ _01647_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__a21oi_1
X_05111_ net707 net880 _01717_ net700 net589 VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__a221o_1
Xhold249 cpuregs\[3\]\[29\] VGND VGND VPWR VPWR net1357 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_104_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold238 cpuregs\[27\]\[17\] VGND VGND VPWR VPWR net1346 sky130_fd_sc_hd__dlygate4sd3_1
X_05042_ _01654_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__inv_2
Xhold227 cpuregs\[27\]\[12\] VGND VGND VPWR VPWR net1335 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_113_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout729 net730 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09850_ net289 net2151 net347 VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__mux2_1
Xfanout707 net710 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__clkbuf_4
Xfanout718 cpu_state\[1\] VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__buf_2
X_06993_ net858 _03403_ net307 VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__mux2_1
X_08801_ net677 _04480_ net666 VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__o21a_1
XFILLER_86_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09781_ net299 net2050 net353 VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__mux2_1
XFILLER_100_559 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05944_ net697 net844 net209 net694 VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__a22o_1
X_08732_ _04416_ _04417_ net482 _04414_ VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_68_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08663_ net672 _04351_ VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__or2_1
X_05875_ _02095_ _02429_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__xnor2_1
XFILLER_93_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_68_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07614_ net1575 net288 net415 VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__mux2_1
XFILLER_54_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08594_ net670 _04286_ VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07545_ net296 net2170 net424 VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_81_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_127_clk clknet_4_9_0_clk VGND VGND VPWR VPWR clknet_leaf_127_clk sky130_fd_sc_hd__clkbuf_8
X_07476_ net1463 net310 net430 VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__mux2_1
X_09215_ _04738_ _01096_ VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__nor2_1
XFILLER_50_874 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06427_ net785 cpuregs\[6\]\[4\] VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__and2b_1
XFILLER_22_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09146_ is_alu_reg_imm _04755_ _04772_ net548 net2335 VGND VGND VPWR VPWR _00869_
+ sky130_fd_sc_hd__a32o_1
X_06358_ net734 _02790_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__and2_1
XFILLER_107_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05309_ reg_pc\[20\] decoded_imm\[20\] VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__or2_1
X_09077_ net2350 net12 net614 VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__mux2_1
X_06289_ cpuregs\[24\]\[0\] cpuregs\[25\]\[0\] cpuregs\[26\]\[0\] cpuregs\[27\]\[0\]
+ net777 net741 VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_112_2124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_79_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08028_ decoded_imm_j\[13\] _03709_ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_15_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold772 cpuregs\[10\]\[28\] VGND VGND VPWR VPWR net1880 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_122_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold750 cpuregs\[26\]\[5\] VGND VGND VPWR VPWR net1858 sky130_fd_sc_hd__dlygate4sd3_1
Xhold761 cpuregs\[9\]\[0\] VGND VGND VPWR VPWR net1869 sky130_fd_sc_hd__dlygate4sd3_1
Xhold794 cpuregs\[17\]\[16\] VGND VGND VPWR VPWR net1902 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_92_1798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold783 cpuregs\[19\]\[6\] VGND VGND VPWR VPWR net1891 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_673 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09979_ clknet_leaf_125_clk _00103_ VGND VGND VPWR VPWR cpuregs\[12\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_123_2297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10823_ clknet_leaf_87_clk _00882_ VGND VGND VPWR VPWR instr_rdcycleh sky130_fd_sc_hd__dfxtp_1
XFILLER_26_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_118_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_118_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_44_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_111_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10754_ clknet_leaf_100_clk alu_out\[1\] VGND VGND VPWR VPWR alu_out_q\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10685_ clknet_leaf_124_clk _00777_ VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_33_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11306_ clknet_leaf_76_clk _01347_ VGND VGND VPWR VPWR cpuregs\[4\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_753 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11237_ clknet_leaf_53_clk _01278_ VGND VGND VPWR VPWR cpuregs\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_106_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_106_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11168_ clknet_leaf_23_clk _01209_ VGND VGND VPWR VPWR cpuregs\[23\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_67_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10119_ clknet_leaf_17_clk _00243_ VGND VGND VPWR VPWR cpuregs\[28\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_143_2618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11099_ clknet_leaf_52_clk _01150_ VGND VGND VPWR VPWR cpuregs\[24\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_900 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_42_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05660_ _02238_ _02239_ VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__nand2_1
XFILLER_63_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05591_ net880 net845 VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__or2_1
Xclkbuf_leaf_109_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_109_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_63_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07330_ net2128 net535 net449 VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09000_ cpuregs\[16\]\[28\] cpuregs\[17\]\[28\] cpuregs\[18\]\[28\] cpuregs\[19\]\[28\]
+ net972 net937 VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_14_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07261_ _03560_ _03565_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__nor2_4
X_06212_ reg_out\[20\] alu_out_q\[20\] net843 VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__mux2_1
X_07192_ latched_rd\[0\] latched_rd\[1\] VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__and2b_1
X_06143_ _02602_ _02603_ net565 VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__mux2_1
X_06074_ cpuregs\[12\]\[3\] cpuregs\[13\]\[3\] cpuregs\[14\]\[3\] cpuregs\[15\]\[3\]
+ net954 net919 VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__mux4_1
X_09902_ net1118 VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__clkbuf_1
XFILLER_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout504 net505 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__clkbuf_4
XFILLER_104_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout515 _02735_ VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__clkbuf_4
X_05025_ is_sll_srl_sra is_lb_lh_lw_lbu_lhu is_sb_sh_sw _01641_ VGND VGND VPWR VPWR
+ _01643_ sky130_fd_sc_hd__or4_1
XFILLER_113_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout526 _02717_ VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__buf_4
Xfanout548 net549 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__buf_2
XFILLER_59_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09833_ net534 net1617 net346 VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__mux2_1
Xfanout537 _02586_ VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout559 _03585_ VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__buf_4
XFILLER_132_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06976_ net859 net510 _03307_ net497 VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__o211a_1
X_09764_ net236 net2165 net359 VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__mux2_1
X_09695_ net2056 net248 net368 VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__mux2_1
X_05927_ net884 _01553_ _01654_ _01659_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__a2bb2o_1
X_08715_ net206 net631 _04400_ _04401_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__o22a_1
X_05858_ _02072_ _02076_ _02400_ VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__or3_1
XFILLER_54_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08646_ cpuregs\[28\]\[9\] cpuregs\[29\]\[9\] cpuregs\[30\]\[9\] cpuregs\[31\]\[9\]
+ net941 net906 VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__mux4_1
X_05789_ _02151_ net585 VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__and2b_1
X_08577_ net670 _04265_ net658 VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__o21a_1
XFILLER_23_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07528_ _03561_ _03579_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__or2_1
X_07459_ net1702 net239 net437 VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_12_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10470_ clknet_leaf_105_clk _00594_ VGND VGND VPWR VPWR count_instr\[13\] sky130_fd_sc_hd__dfxtp_1
X_09129_ net2282 net548 _04760_ is_sb_sh_sw VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__a22o_1
XFILLER_6_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_108_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_94_1838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_701 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold580 cpuregs\[4\]\[6\] VGND VGND VPWR VPWR net1688 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_150_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold591 cpuregs\[7\]\[27\] VGND VGND VPWR VPWR net1699 sky130_fd_sc_hd__dlygate4sd3_1
X_11022_ clknet_leaf_44_clk _01078_ VGND VGND VPWR VPWR cpuregs\[19\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_131_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_89_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_125_2326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_64_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10806_ clknet_leaf_96_clk _00865_ VGND VGND VPWR VPWR instr_ori sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_45_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10737_ clknet_leaf_56_clk _00828_ VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_31_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10668_ clknet_leaf_60_clk _04893_ VGND VGND VPWR VPWR reg_out\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_153_2791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput107 net107 VGND VGND VPWR VPWR mem_la_wdata[19] sky130_fd_sc_hd__buf_2
X_10599_ clknet_leaf_86_clk _00723_ VGND VGND VPWR VPWR count_cycle\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput118 net118 VGND VGND VPWR VPWR mem_la_wdata[29] sky130_fd_sc_hd__buf_2
Xoutput129 net129 VGND VGND VPWR VPWR mem_la_write sky130_fd_sc_hd__buf_2
XFILLER_142_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_50_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06830_ decoded_imm\[19\] net865 VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__and2_1
XFILLER_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06761_ cpuregs\[20\]\[16\] cpuregs\[21\]\[16\] cpuregs\[22\]\[16\] cpuregs\[23\]\[16\]
+ net799 net762 VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__mux4_1
X_08500_ net84 net1466 net409 VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__mux2_1
X_06692_ reg_pc\[13\] net560 _03113_ net516 net520 VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__a221o_1
XFILLER_64_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09480_ net1318 net319 net389 VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__mux2_1
X_05712_ _02166_ _02284_ _02285_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_19_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08431_ count_cycle\[63\] _04165_ net1001 VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__a21bo_1
X_05643_ _02096_ _02222_ _02177_ VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__a21oi_1
XFILLER_63_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05574_ net873 net207 VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__and2_1
X_08362_ net2267 _04120_ _04122_ VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__a21oi_1
X_07313_ net2111 net289 net451 VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__mux2_1
X_08293_ _04079_ net987 _04078_ VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__and3b_1
X_07244_ net1425 net302 net459 VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__mux2_1
XFILLER_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07175_ net1376 net297 net468 VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06126_ reg_pc\[3\] reg_pc\[2\] VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__xor2_1
X_06057_ decoded_imm_j\[3\] decoded_imm_j\[1\] _02526_ VGND VGND VPWR VPWR _02527_
+ sky130_fd_sc_hd__nor3_1
XFILLER_99_682 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_800 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout301 net302 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__clkbuf_2
Xfanout312 net315 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_2
Xfanout323 net324 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__clkbuf_2
X_05008_ net707 _01623_ _01625_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__and3_1
Xfanout356 _04877_ VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__buf_4
XFILLER_101_632 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout345 net346 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkbuf_8
XFILLER_143_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09816_ net294 net2075 net351 VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__mux2_1
Xfanout367 net368 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__clkbuf_8
Xfanout378 net379 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__buf_4
Xfanout389 net390 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__clkbuf_8
X_06959_ _03361_ _03362_ net735 VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_2045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_101_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09747_ net308 net1940 net359 VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__mux2_1
XFILLER_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09678_ net1567 net320 net365 VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_120_2256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08629_ cpuregs\[4\]\[8\] cpuregs\[5\]\[8\] cpuregs\[6\]\[8\] cpuregs\[7\]\[8\] net941
+ net906 VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__mux4_1
XFILLER_30_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10522_ clknet_leaf_129_clk _00646_ VGND VGND VPWR VPWR reg_pc\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_10_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10453_ clknet_leaf_72_clk _00577_ VGND VGND VPWR VPWR cpuregs\[17\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_136_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10384_ clknet_leaf_52_clk _00508_ VGND VGND VPWR VPWR cpuregs\[25\]\[24\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_107_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_779 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_123_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_78_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11005_ clknet_leaf_24_clk _01061_ VGND VGND VPWR VPWR cpuregs\[18\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_77_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout890 net891 VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_36_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_116_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_138_2539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_40_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_40_clk sky130_fd_sc_hd__clkbuf_8
X_05290_ _01882_ _01883_ net714 VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__or3b_1
XFILLER_6_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_142_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08980_ cpuregs\[4\]\[27\] cpuregs\[5\]\[27\] cpuregs\[6\]\[27\] cpuregs\[7\]\[27\]
+ net972 net937 VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__mux4_1
X_07931_ decoded_imm_j\[5\] _03701_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__nor2_1
X_07862_ reg_pc\[13\] net502 _03709_ net602 VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_71_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06813_ cpuregs\[20\]\[18\] cpuregs\[21\]\[18\] cpuregs\[22\]\[18\] cpuregs\[23\]\[18\]
+ net792 net755 VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__mux4_1
X_09601_ net535 net1745 net374 VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__mux2_1
XFILLER_3_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09532_ net1778 net237 net387 VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__mux2_1
XFILLER_84_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07793_ count_instr\[48\] _03667_ net995 VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__o21ai_1
XFILLER_92_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06744_ _03093_ _03116_ _03140_ VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__or3_1
X_09463_ net249 net1906 net395 VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__mux2_1
X_06675_ net868 net513 VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__or2_1
X_08414_ _04155_ net1000 _04154_ VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__and3b_1
X_05626_ _02120_ _02160_ _02195_ _02205_ VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__o31a_2
X_09394_ decoded_imm\[3\] net552 _04859_ _04860_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__o22a_1
X_08345_ count_cycle\[31\] _04110_ net994 VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__o21ai_1
X_05557_ net876 net234 VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__nand2_1
XFILLER_51_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_149_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_31_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_31_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_149_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05488_ _02059_ _02062_ _02066_ VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__or3_1
X_08276_ count_cycle\[4\] count_cycle\[5\] _04065_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__and3_1
X_07227_ latched_rd\[1\] latched_rd\[0\] _02579_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__nand3b_4
XFILLER_152_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_98_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07158_ _03559_ _03561_ VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__nor2_4
XFILLER_106_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06109_ net811 decoded_imm_j\[4\] net705 VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__a21oi_1
X_07089_ cpuregs\[4\]\[28\] cpuregs\[5\]\[28\] cpuregs\[6\]\[28\] cpuregs\[7\]\[28\]
+ net805 net768 VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_98_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_98_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_75_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_87_685 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_90_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_100_1926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_22_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10505_ clknet_leaf_84_clk _00629_ VGND VGND VPWR VPWR count_instr\[48\] sky130_fd_sc_hd__dfxtp_1
X_11485_ clknet_leaf_10_clk _01523_ VGND VGND VPWR VPWR cpuregs\[10\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_133_2458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_584 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10436_ clknet_leaf_4_clk _00560_ VGND VGND VPWR VPWR cpuregs\[17\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_88_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10367_ clknet_leaf_148_clk _00491_ VGND VGND VPWR VPWR cpuregs\[25\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10298_ clknet_leaf_117_clk _00422_ VGND VGND VPWR VPWR cpuregs\[26\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_89_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_89_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_77_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_53_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_93_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06460_ net644 _02889_ net722 VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__o21a_1
X_05411_ net715 _01989_ _01995_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__a21o_1
X_08130_ net689 reg_next_pc\[20\] net546 _03717_ VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__a22o_1
Xclkbuf_leaf_13_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
X_06391_ cpuregs\[16\]\[3\] cpuregs\[17\]\[3\] cpuregs\[18\]\[3\] cpuregs\[19\]\[3\]
+ net786 net749 VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__mux4_1
X_05342_ count_instr\[54\] net818 net825 count_cycle\[54\] VGND VGND VPWR VPWR _01932_
+ sky130_fd_sc_hd__a22o_1
XFILLER_147_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08061_ _03711_ _03864_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__and2_1
X_05273_ net704 net344 _01865_ net709 net178 VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__a32o_1
X_07012_ _03413_ _03414_ net736 VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__mux2_1
XFILLER_128_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08963_ cpuregs\[8\]\[26\] cpuregs\[9\]\[26\] cpuregs\[10\]\[26\] cpuregs\[11\]\[26\]
+ net969 net934 VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__mux4_1
XFILLER_103_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_102_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07914_ decoded_imm_j\[1\] _03695_ _03734_ _03733_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__a31oi_2
X_08894_ net892 _04567_ _04570_ net480 VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__o211a_1
XFILLER_84_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07845_ _02597_ reg_next_pc\[5\] net570 VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__mux2_2
XFILLER_140_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04988_ net700 cpu_state\[5\] VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__or2_1
XFILLER_56_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07776_ _03657_ _03658_ VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__nor2_1
X_09515_ net1467 net310 net387 VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__mux2_1
XFILLER_71_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06727_ cpuregs\[4\]\[15\] cpuregs\[5\]\[15\] cpuregs\[6\]\[15\] cpuregs\[7\]\[15\]
+ net783 net747 VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__mux4_1
XFILLER_17_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_84_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09446_ net321 net1903 net393 VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__mux2_1
X_06658_ cpuregs\[20\]\[12\] cpuregs\[21\]\[12\] cpuregs\[22\]\[12\] cpuregs\[23\]\[12\]
+ net778 net742 VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__mux4_1
X_09377_ net833 decoded_imm_j\[10\] _04826_ mem_rdata_q\[30\] net550 VGND VGND VPWR
+ VPWR _04851_ sky130_fd_sc_hd__a221o_1
X_06589_ _02959_ _02963_ _02985_ _02986_ VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__a31oi_2
X_05609_ _02163_ _02187_ _02188_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__a21oi_1
XFILLER_33_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_137_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08328_ _04100_ _04101_ VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__nor2_1
X_08259_ _04056_ _04057_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__xnor2_1
X_11270_ clknet_leaf_51_clk _01311_ VGND VGND VPWR VPWR cpuregs\[22\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_115_2177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10221_ clknet_leaf_36_clk _00345_ VGND VGND VPWR VPWR cpuregs\[14\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10152_ clknet_leaf_44_clk _00276_ VGND VGND VPWR VPWR cpuregs\[21\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_79_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10083_ clknet_leaf_5_clk _00207_ VGND VGND VPWR VPWR cpuregs\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
Xhold9 instr_fence VGND VGND VPWR VPWR net1117 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_47_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10985_ clknet_leaf_1_clk _01041_ VGND VGND VPWR VPWR cpuregs\[18\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_31_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_128_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold409 cpuregs\[14\]\[22\] VGND VGND VPWR VPWR net1517 sky130_fd_sc_hd__dlygate4sd3_1
X_11468_ clknet_leaf_71_clk _01506_ VGND VGND VPWR VPWR cpuregs\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11399_ clknet_leaf_46_clk _01437_ VGND VGND VPWR VPWR cpuregs\[7\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_10419_ clknet_leaf_67_clk _00543_ VGND VGND VPWR VPWR cpuregs\[20\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_100_708 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_97_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05960_ net226 net595 _02481_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__a21o_1
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_2_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
Xhold1109 reg_next_pc\[3\] VGND VGND VPWR VPWR net2217 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05891_ _02442_ _02443_ net693 VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__mux2_1
XFILLER_38_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07630_ net534 net2015 net411 VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__mux2_1
XFILLER_93_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07561_ latched_rd\[1\] latched_rd\[0\] _03575_ VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__and3b_2
X_09300_ net1148 net114 net485 VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__mux2_1
X_06512_ _01559_ net506 VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__nand2_1
XFILLER_53_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_24_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07492_ net1503 net241 net433 VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__mux2_1
XFILLER_110_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1016 VGND VGND VPWR VPWR picorv32_1016/HI eoi[13] sky130_fd_sc_hd__conb_1
Xpicorv32_1005 VGND VGND VPWR VPWR picorv32_1005/HI eoi[2] sky130_fd_sc_hd__conb_1
Xpicorv32_1027 VGND VGND VPWR VPWR picorv32_1027/HI eoi[24] sky130_fd_sc_hd__conb_1
XFILLER_148_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xpicorv32_1038 VGND VGND VPWR VPWR picorv32_1038/HI mem_la_addr[1] sky130_fd_sc_hd__conb_1
Xpicorv32_1049 VGND VGND VPWR VPWR picorv32_1049/HI pcpi_insn[10] sky130_fd_sc_hd__conb_1
XFILLER_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09231_ net1813 net493 net403 VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__mux2_1
X_06443_ net488 _02774_ _02871_ _02873_ _02870_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__a311o_1
X_09162_ mem_rdata_q\[29\] mem_rdata_q\[28\] VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__nor2_1
XFILLER_9_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06374_ _02804_ _02806_ _02778_ _02781_ VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__a211o_1
X_05325_ _01903_ _01904_ _01902_ VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__o21ai_1
X_08113_ _03910_ _03923_ _03921_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__a21oi_1
X_09093_ net838 _02515_ _04744_ _04745_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__a22o_1
XFILLER_135_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold910 cpuregs\[8\]\[24\] VGND VGND VPWR VPWR net2018 sky130_fd_sc_hd__dlygate4sd3_1
X_08044_ decoded_imm_j\[14\] _03710_ VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__or2_1
X_05256_ net709 net871 _01843_ _01849_ _01852_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__a2111o_1
Xhold921 net197 VGND VGND VPWR VPWR net2029 sky130_fd_sc_hd__dlygate4sd3_1
Xhold932 cpuregs\[16\]\[19\] VGND VGND VPWR VPWR net2040 sky130_fd_sc_hd__dlygate4sd3_1
Xhold943 cpuregs\[8\]\[13\] VGND VGND VPWR VPWR net2051 sky130_fd_sc_hd__dlygate4sd3_1
X_05187_ net716 _01782_ _01783_ _01788_ VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__a31o_1
Xhold954 cpuregs\[14\]\[0\] VGND VGND VPWR VPWR net2062 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_135_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_131_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold976 cpuregs\[18\]\[21\] VGND VGND VPWR VPWR net2084 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold987 cpuregs\[3\]\[18\] VGND VGND VPWR VPWR net2095 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_88_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold965 cpuregs\[15\]\[19\] VGND VGND VPWR VPWR net2073 sky130_fd_sc_hd__dlygate4sd3_1
Xhold998 cpuregs\[22\]\[4\] VGND VGND VPWR VPWR net2106 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_142_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_131_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09995_ clknet_leaf_22_clk _00119_ VGND VGND VPWR VPWR cpuregs\[12\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_08946_ _04611_ _04612_ net683 VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_110_2096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08877_ net892 _04553_ net666 VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__a21o_1
XFILLER_57_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07828_ count_instr\[61\] count_instr\[60\] _03687_ VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_86_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_72_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_151_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07759_ net2321 _03646_ net980 VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__o21ai_1
XFILLER_44_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10770_ clknet_leaf_59_clk alu_out\[17\] VGND VGND VPWR VPWR alu_out_q\[17\] sky130_fd_sc_hd__dfxtp_1
X_09429_ net252 net1952 net399 VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__mux2_1
XFILLER_13_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_2206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_130_2417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11322_ clknet_leaf_9_clk _01363_ VGND VGND VPWR VPWR cpuregs\[5\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11253_ clknet_leaf_3_clk _01294_ VGND VGND VPWR VPWR cpuregs\[22\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10204_ clknet_leaf_142_clk _00328_ VGND VGND VPWR VPWR cpuregs\[14\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11184_ clknet_leaf_124_clk _01225_ VGND VGND VPWR VPWR cpuregs\[29\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_10135_ clknet_leaf_55_clk _00259_ VGND VGND VPWR VPWR cpuregs\[28\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10066_ clknet_leaf_49_clk _00190_ VGND VGND VPWR VPWR cpuregs\[13\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_48_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_128_2379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10968_ clknet_leaf_131_clk _01024_ VGND VGND VPWR VPWR decoded_imm\[6\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_48_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10899_ clknet_leaf_101_clk _00955_ VGND VGND VPWR VPWR mem_state\[1\] sky130_fd_sc_hd__dfxtp_1
X_05110_ net14 _01656_ net130 net28 _01716_ VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__a221o_1
Xhold217 cpuregs\[1\]\[11\] VGND VGND VPWR VPWR net1325 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_7_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold206 net37 VGND VGND VPWR VPWR net1314 sky130_fd_sc_hd__dlygate4sd3_1
X_06090_ _01647_ _02539_ _02557_ _02558_ VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__o22a_1
Xhold228 cpuregs\[1\]\[17\] VGND VGND VPWR VPWR net1336 sky130_fd_sc_hd__dlygate4sd3_1
X_05041_ net884 net695 VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__nand2_4
Xhold239 cpuregs\[5\]\[0\] VGND VGND VPWR VPWR net1347 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_113_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout708 net709 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__buf_2
X_08800_ net902 _04481_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__or2_1
Xfanout719 mem_rdata_q\[14\] VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__buf_2
XFILLER_113_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06992_ net525 _03384_ _03386_ _03387_ _03402_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__o41a_1
XFILLER_86_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09780_ net308 net2032 net355 VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05943_ net696 net125 net208 net593 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__a22o_1
X_08731_ net890 _04415_ net665 VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_68_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08662_ cpuregs\[20\]\[10\] cpuregs\[21\]\[10\] cpuregs\[22\]\[10\] cpuregs\[23\]\[10\]
+ net946 net911 VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__mux4_1
X_05874_ _02427_ _02428_ _02426_ VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__o21a_1
X_07613_ net1331 net293 net415 VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__mux2_1
XFILLER_81_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08593_ cpuregs\[12\]\[6\] cpuregs\[13\]\[6\] cpuregs\[14\]\[6\] cpuregs\[15\]\[6\]
+ net943 net908 VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__mux4_1
XFILLER_81_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07544_ net299 net2227 net423 VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__mux2_1
X_07475_ net1694 net313 net431 VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__mux2_1
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09214_ _01099_ _01098_ VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__nor2_1
XFILLER_50_886 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06426_ net751 _02856_ _02855_ net649 VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__o211a_1
X_09145_ net550 _04769_ _04770_ VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__nor3_1
X_06357_ cpuregs\[20\]\[2\] cpuregs\[21\]\[2\] cpuregs\[22\]\[2\] cpuregs\[23\]\[2\]
+ net788 net753 VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__mux4_1
X_05308_ net714 _01894_ _01900_ VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__a21o_1
X_09076_ net2334 net1 net614 VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__mux2_1
X_06288_ cpuregs\[28\]\[0\] cpuregs\[29\]\[0\] cpuregs\[30\]\[0\] cpuregs\[31\]\[0\]
+ net782 net746 VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_112_2125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05239_ net710 net176 net591 _01836_ _01834_ VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__a221o_1
X_08027_ _03709_ _03839_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__xnor2_1
XFILLER_2_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold762 cpuregs\[15\]\[28\] VGND VGND VPWR VPWR net1870 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold773 cpuregs\[6\]\[26\] VGND VGND VPWR VPWR net1881 sky130_fd_sc_hd__dlygate4sd3_1
Xhold740 cpuregs\[14\]\[21\] VGND VGND VPWR VPWR net1848 sky130_fd_sc_hd__dlygate4sd3_1
Xhold751 cpuregs\[18\]\[24\] VGND VGND VPWR VPWR net1859 sky130_fd_sc_hd__dlygate4sd3_1
Xhold784 cpuregs\[6\]\[23\] VGND VGND VPWR VPWR net1892 sky130_fd_sc_hd__dlygate4sd3_1
Xhold795 cpuregs\[19\]\[11\] VGND VGND VPWR VPWR net1903 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_92_1799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09978_ clknet_leaf_115_clk _00102_ VGND VGND VPWR VPWR cpuregs\[12\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_130_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08929_ _04593_ _04594_ net683 VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__mux2_1
XFILLER_29_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_85_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_658 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_123_2298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10822_ clknet_leaf_87_clk _00881_ VGND VGND VPWR VPWR instr_rdcycle sky130_fd_sc_hd__dfxtp_1
XFILLER_72_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10753_ clknet_leaf_131_clk alu_out\[0\] VGND VGND VPWR VPWR alu_out_q\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_99_1909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_752 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10684_ clknet_leaf_124_clk _00776_ VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dfxtp_1
XFILLER_41_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_139_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11305_ clknet_leaf_72_clk _01346_ VGND VGND VPWR VPWR cpuregs\[4\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_114_619 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_141_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11236_ clknet_leaf_46_clk _01277_ VGND VGND VPWR VPWR cpuregs\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_141_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_121_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11167_ clknet_leaf_33_clk _01208_ VGND VGND VPWR VPWR cpuregs\[23\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_68_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10118_ clknet_leaf_26_clk _00242_ VGND VGND VPWR VPWR cpuregs\[28\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_143_2619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11098_ clknet_leaf_48_clk _01149_ VGND VGND VPWR VPWR cpuregs\[24\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10049_ clknet_leaf_153_clk _00173_ VGND VGND VPWR VPWR cpuregs\[13\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05590_ net880 net845 VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_63_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_44_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_91_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07260_ net1764 net237 net460 VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06211_ net283 net2087 net478 VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__mux2_1
X_07191_ latched_rd\[2\] latched_rd\[3\] latched_rd\[4\] VGND VGND VPWR VPWR _03563_
+ sky130_fd_sc_hd__nand3_2
XFILLER_145_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06142_ reg_pc\[6\] _02599_ VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__xor2_1
XFILLER_105_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06073_ _02540_ _02541_ net674 VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__mux2_1
X_09901_ net1123 VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__clkbuf_1
XFILLER_99_820 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05024_ is_lb_lh_lw_lbu_lhu _01641_ VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__nor2_1
Xfanout505 _03698_ VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__clkbuf_4
XFILLER_99_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_113_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_99_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout516 net517 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout538 net539 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__clkbuf_2
X_09832_ net538 net2201 net345 VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__mux2_1
Xfanout527 net528 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__clkbuf_2
X_09763_ net240 net1897 net360 VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__mux2_1
XFILLER_101_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout549 net550 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__clkbuf_2
XFILLER_132_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06975_ net864 net509 net489 _03385_ VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__o211a_1
X_08714_ decoded_imm\[12\] net600 net626 VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__a21o_1
X_09694_ net2148 net253 net368 VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__mux2_1
X_05926_ net852 net227 net580 _02472_ _02474_ VGND VGND VPWR VPWR alu_out\[31\] sky130_fd_sc_hd__a311o_1
XFILLER_82_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05857_ _02052_ _02412_ _02413_ VGND VGND VPWR VPWR alu_out\[23\] sky130_fd_sc_hd__o21ai_1
XFILLER_15_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08645_ net899 _04334_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__or2_1
XFILLER_27_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08576_ cpuregs\[8\]\[5\] cpuregs\[9\]\[5\] cpuregs\[10\]\[5\] cpuregs\[11\]\[5\]
+ net944 net909 VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__mux4_1
X_05788_ _02152_ _02351_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__or2_1
X_07527_ latched_rd\[2\] latched_rd\[3\] latched_rd\[4\] VGND VGND VPWR VPWR _03579_
+ sky130_fd_sc_hd__or3b_1
XFILLER_42_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07458_ net1327 net244 net437 VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__mux2_1
XFILLER_10_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07389_ net253 net1938 net445 VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__mux2_1
X_06409_ net523 net517 _02831_ _02840_ net303 VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__a311o_1
X_09128_ net2302 net548 _04755_ _04765_ VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__a22o_1
XFILLER_136_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_135_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_123_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09059_ _04724_ _04726_ net480 _04723_ VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__o211a_1
XFILLER_2_713 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_151_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold581 cpuregs\[8\]\[25\] VGND VGND VPWR VPWR net1689 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_89_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold570 cpuregs\[10\]\[15\] VGND VGND VPWR VPWR net1678 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11021_ clknet_leaf_26_clk _01077_ VGND VGND VPWR VPWR cpuregs\[19\]\[15\] sky130_fd_sc_hd__dfxtp_1
Xhold592 cpuregs\[12\]\[12\] VGND VGND VPWR VPWR net1700 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_125_2338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1270 decoded_imm\[17\] VGND VGND VPWR VPWR net2378 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_73_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10805_ clknet_leaf_97_clk _00864_ VGND VGND VPWR VPWR instr_xori sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_103_1979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10736_ clknet_leaf_56_clk _00827_ VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dfxtp_2
XFILLER_9_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10667_ clknet_leaf_94_clk _04891_ VGND VGND VPWR VPWR reg_out\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_153_2792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10598_ clknet_leaf_104_clk _00722_ VGND VGND VPWR VPWR count_cycle\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_99_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput119 net846 VGND VGND VPWR VPWR mem_la_wdata[2] sky130_fd_sc_hd__buf_2
Xoutput108 net108 VGND VGND VPWR VPWR mem_la_wdata[1] sky130_fd_sc_hd__buf_2
XFILLER_96_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11219_ clknet_leaf_145_clk _01260_ VGND VGND VPWR VPWR cpuregs\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_68_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput90 net90 VGND VGND VPWR VPWR mem_la_addr[4] sky130_fd_sc_hd__buf_2
X_06760_ cpuregs\[0\]\[16\] cpuregs\[1\]\[16\] cpuregs\[2\]\[16\] cpuregs\[3\]\[16\]
+ net799 net762 VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__mux4_1
XFILLER_83_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06691_ _03109_ _03110_ _03112_ _03111_ net727 net722 VGND VGND VPWR VPWR _03113_
+ sky130_fd_sc_hd__mux4_2
X_05711_ _02166_ _02284_ net543 VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_19_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08430_ _04165_ net1001 _04164_ VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__and3b_1
X_05642_ net226 net194 VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__and2b_1
XFILLER_91_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_904 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05573_ net873 net207 VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__nor2_1
X_08361_ count_cycle\[37\] _04120_ net981 VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__o21ai_1
XFILLER_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_149_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07312_ net1968 net293 net451 VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__mux2_1
X_08292_ count_cycle\[10\] count_cycle\[11\] _04075_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__and3_1
XFILLER_32_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07243_ net1819 net310 net458 VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__mux2_1
XFILLER_20_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_118_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07174_ net1387 net301 net467 VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__mux2_1
XFILLER_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_127_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06125_ reg_out\[3\] alu_out_q\[3\] net840 VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__mux2_1
XFILLER_132_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_105_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06056_ decoded_imm_j\[11\] decoded_imm_j\[4\] decoded_imm_j\[2\] VGND VGND VPWR
+ VPWR _02526_ sky130_fd_sc_hd__or3_1
Xfanout302 _02642_ VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__clkbuf_2
Xfanout313 net315 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlymetal6s2s_1
X_05007_ _01554_ _01626_ VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__nor2_2
XFILLER_143_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09815_ net297 net1847 net351 VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__mux2_1
XFILLER_101_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_694 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout324 net325 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__clkbuf_2
Xfanout357 net358 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__clkbuf_8
Xfanout346 _04879_ VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__buf_4
Xfanout335 net336 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__clkbuf_2
Xfanout379 net380 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__clkbuf_8
Xfanout368 _04874_ VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__buf_4
XFILLER_101_644 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06958_ _03363_ _03364_ net654 VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__mux2_1
XFILLER_100_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09746_ net312 net2089 net357 VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_2046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05909_ _02081_ _02459_ net580 _02079_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__a2bb2o_1
X_09677_ net1775 net325 net365 VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__mux2_1
XFILLER_54_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06889_ _03274_ _03297_ _03298_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__and3_1
X_08628_ cpuregs\[24\]\[8\] cpuregs\[25\]\[8\] cpuregs\[26\]\[8\] cpuregs\[27\]\[8\]
+ net942 net907 VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__mux4_1
XFILLER_27_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_2246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08559_ net846 _04255_ net630 VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__mux2_1
XFILLER_139_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_491 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10521_ clknet_leaf_118_clk _00645_ VGND VGND VPWR VPWR reg_pc\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_11_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10452_ clknet_leaf_70_clk _00576_ VGND VGND VPWR VPWR cpuregs\[17\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_10383_ clknet_leaf_45_clk _00507_ VGND VGND VPWR VPWR cpuregs\[25\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_112_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_123_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11004_ clknet_leaf_64_clk _01060_ VGND VGND VPWR VPWR cpuregs\[18\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_65_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout891 _00011_ VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__buf_2
Xfanout880 net198 VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__clkbuf_4
XFILLER_133_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_93_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10719_ clknet_leaf_141_clk _00810_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dfxtp_4
XFILLER_147_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_758 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07930_ _03754_ _03755_ net977 VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__o21a_1
XFILLER_110_430 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07861_ _02630_ reg_next_pc\[13\] net569 VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__mux2_2
XTAP_TAPCELL_ROW_71_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_110_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06812_ cpuregs\[0\]\[18\] cpuregs\[1\]\[18\] cpuregs\[2\]\[18\] cpuregs\[3\]\[18\]
+ net792 net755 VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__mux4_1
XFILLER_96_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07792_ _03667_ _03668_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__nor2_1
XFILLER_56_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09600_ net539 net1806 net374 VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__mux2_1
X_09531_ net1685 net239 net388 VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__mux2_1
X_06743_ net870 net303 VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__and2_1
XFILLER_52_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09462_ net252 net2044 net395 VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__mux2_1
X_06674_ _03095_ _03094_ VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__and2b_1
XFILLER_52_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08413_ count_cycle\[55\] count_cycle\[56\] _04151_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__and3_1
X_05625_ _02160_ _02198_ _02204_ _02152_ _02202_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__o221a_1
X_09393_ net835 decoded_imm_j\[3\] _04825_ mem_rdata_q\[10\] net551 VGND VGND VPWR
+ VPWR _04860_ sky130_fd_sc_hd__a221o_1
X_08344_ _04110_ _04111_ VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__nor2_1
X_05556_ net876 net234 VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__nor2_1
XFILLER_20_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05487_ _02066_ VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__inv_2
XFILLER_22_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08275_ count_cycle\[4\] _04065_ count_cycle\[5\] VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__a21o_1
XFILLER_118_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07226_ net1761 net236 net464 VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__mux2_1
XFILLER_146_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07157_ latched_rd\[1\] latched_rd\[0\] _02579_ _03560_ VGND VGND VPWR VPWR _03561_
+ sky130_fd_sc_hd__or4bb_4
XFILLER_106_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06108_ net811 _02527_ _02567_ _02575_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__or4_1
XFILLER_133_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_105_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07088_ net607 _03489_ _03490_ _03494_ VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__a31o_1
XFILLER_120_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06039_ net2329 net9 net613 VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__mux2_1
XFILLER_59_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09729_ net245 net1238 net364 VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_89_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_59_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_63_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_100_1927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10504_ clknet_leaf_105_clk _00628_ VGND VGND VPWR VPWR count_instr\[47\] sky130_fd_sc_hd__dfxtp_1
X_11484_ clknet_leaf_4_clk _01522_ VGND VGND VPWR VPWR cpuregs\[10\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_21_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_2459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10435_ clknet_leaf_1_clk _00559_ VGND VGND VPWR VPWR cpuregs\[17\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_124_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_124_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_596 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_112_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10366_ clknet_leaf_143_clk _00490_ VGND VGND VPWR VPWR cpuregs\[25\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_88_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10297_ clknet_leaf_114_clk _00421_ VGND VGND VPWR VPWR cpuregs\[26\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_53_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_92_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_807 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05410_ net703 net343 _01990_ _01994_ VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__a31o_1
X_06390_ _02816_ _02818_ _02821_ net640 net727 VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__o221a_1
XFILLER_21_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05341_ net704 net344 _01930_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__and3_1
XFILLER_135_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08060_ _03711_ _03864_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__or2_1
X_05272_ count_cycle\[16\] net620 net591 _01867_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__o211a_1
X_07011_ _03419_ _03420_ net656 VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__mux2_1
XFILLER_128_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_127_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_108_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08962_ net683 _04634_ VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__or2_1
XFILLER_143_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_130_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_115_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_88_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08893_ net667 _04568_ _04569_ _04562_ net661 VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__a221o_1
X_07913_ _03738_ _03739_ VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__nand2_1
XFILLER_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07844_ reg_pc\[4\] net502 _03700_ net602 VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__a22o_1
XFILLER_110_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_04987_ net700 cpu_state\[5\] VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__nor2_1
X_07775_ net2301 _03656_ net986 VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__o21ai_1
XFILLER_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_140_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06726_ net872 net510 _03073_ net497 VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__o211a_1
X_09514_ net1448 net315 net385 VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__mux2_1
XFILLER_64_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_84_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06657_ cpuregs\[0\]\[12\] cpuregs\[1\]\[12\] cpuregs\[2\]\[12\] cpuregs\[3\]\[12\]
+ net778 net742 VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__mux4_1
X_09445_ net324 net2081 net393 VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__mux2_1
XFILLER_24_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_84_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05608_ net123 net881 VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_135_Left_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09376_ decoded_imm\[11\] net556 _04849_ _04850_ VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__o22a_1
X_06588_ _03011_ _03012_ VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__and2_1
XFILLER_12_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08327_ net2244 _04099_ net992 VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__o21ai_1
X_05539_ net173 net205 VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__or2_1
XFILLER_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08258_ decoded_imm_j\[20\] _03728_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__xor2_1
XFILLER_20_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_153_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07209_ net1609 net310 net463 VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__mux2_1
X_10220_ clknet_leaf_36_clk _00344_ VGND VGND VPWR VPWR cpuregs\[14\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_08189_ net686 _03992_ _03993_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_115_2178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10151_ clknet_leaf_22_clk _00275_ VGND VGND VPWR VPWR cpuregs\[21\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_58_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_144_Left_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_94_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10082_ clknet_leaf_12_clk _00206_ VGND VGND VPWR VPWR cpuregs\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_7_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_848 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_550 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10984_ clknet_leaf_13_clk _01040_ VGND VGND VPWR VPWR cpuregs\[18\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_15_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_117_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11467_ clknet_leaf_70_clk _01505_ VGND VGND VPWR VPWR cpuregs\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_109_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11398_ clknet_leaf_40_clk _01436_ VGND VGND VPWR VPWR cpuregs\[7\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_10418_ clknet_leaf_51_clk _00542_ VGND VGND VPWR VPWR cpuregs\[20\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10349_ clknet_leaf_36_clk _00473_ VGND VGND VPWR VPWR cpuregs\[16\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_97_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_97_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05890_ _02106_ _02435_ _02105_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__o21ba_1
XFILLER_66_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_623 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07560_ net238 net1817 net423 VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__mux2_1
XFILLER_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06511_ net199 net506 VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__or2_1
X_07491_ net1396 net246 net433 VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_372 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09230_ net1478 net529 net403 VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1006 VGND VGND VPWR VPWR picorv32_1006/HI eoi[3] sky130_fd_sc_hd__conb_1
XFILLER_34_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xpicorv32_1028 VGND VGND VPWR VPWR picorv32_1028/HI eoi[25] sky130_fd_sc_hd__conb_1
Xpicorv32_1039 VGND VGND VPWR VPWR picorv32_1039/HI pcpi_insn[0] sky130_fd_sc_hd__conb_1
Xpicorv32_1017 VGND VGND VPWR VPWR picorv32_1017/HI eoi[14] sky130_fd_sc_hd__conb_1
X_06442_ net495 _02872_ net523 VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__a21o_1
X_09161_ is_alu_reg_imm _04755_ _04775_ net550 net1260 VGND VGND VPWR VPWR _00880_
+ sky130_fd_sc_hd__a32o_1
X_06373_ decoded_imm\[2\] net883 VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__or2_1
X_05324_ _01913_ _01914_ VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__and2b_1
X_08112_ _03903_ _03922_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__or2_1
X_09092_ _01094_ _01095_ _01097_ _01096_ VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__and4_1
XFILLER_9_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08043_ decoded_imm_j\[14\] _03710_ VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__nand2_1
Xhold900 cpuregs\[23\]\[26\] VGND VGND VPWR VPWR net2008 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_128_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05255_ count_cycle\[15\] net620 net591 _01851_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__o211a_1
Xhold922 cpuregs\[9\]\[10\] VGND VGND VPWR VPWR net2030 sky130_fd_sc_hd__dlygate4sd3_1
Xhold911 cpuregs\[12\]\[4\] VGND VGND VPWR VPWR net2019 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_150_609 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold944 cpuregs\[11\]\[21\] VGND VGND VPWR VPWR net2052 sky130_fd_sc_hd__dlygate4sd3_1
Xhold933 cpuregs\[11\]\[15\] VGND VGND VPWR VPWR net2041 sky130_fd_sc_hd__dlygate4sd3_1
X_05186_ net707 net172 net592 _01787_ _01785_ VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__a221o_1
Xhold955 cpuregs\[10\]\[10\] VGND VGND VPWR VPWR net2063 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_135_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold988 cpuregs\[16\]\[30\] VGND VGND VPWR VPWR net2096 sky130_fd_sc_hd__dlygate4sd3_1
X_09994_ clknet_leaf_35_clk _00118_ VGND VGND VPWR VPWR cpuregs\[12\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold977 cpuregs\[8\]\[11\] VGND VGND VPWR VPWR net2085 sky130_fd_sc_hd__dlygate4sd3_1
Xhold966 cpuregs\[5\]\[1\] VGND VGND VPWR VPWR net2074 sky130_fd_sc_hd__dlygate4sd3_1
Xhold999 cpuregs\[16\]\[25\] VGND VGND VPWR VPWR net2107 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_88_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08945_ net683 _04613_ net663 VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__o21a_1
XFILLER_131_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_2097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08876_ net903 _04549_ _04548_ net661 VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__o211a_1
X_07827_ count_instr\[60\] _03687_ count_instr\[61\] VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_86_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_84_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07758_ count_instr\[35\] count_instr\[34\] count_instr\[33\] _03642_ VGND VGND VPWR
+ VPWR _03647_ sky130_fd_sc_hd__and4_1
X_06709_ cpuregs\[16\]\[14\] cpuregs\[17\]\[14\] cpuregs\[18\]\[14\] cpuregs\[19\]\[14\]
+ net791 net754 VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__mux4_1
XFILLER_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07689_ count_instr\[10\] count_instr\[9\] count_instr\[8\] _03598_ VGND VGND VPWR
+ VPWR _03603_ sky130_fd_sc_hd__and4_1
XFILLER_53_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09428_ net255 net1884 net398 VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__mux2_1
X_09359_ decoded_imm\[19\] net553 _04827_ _04841_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_117_2207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_60_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_770 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11321_ clknet_leaf_6_clk _01362_ VGND VGND VPWR VPWR cpuregs\[5\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_130_2418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_2407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_152_Left_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_107_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_21 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11252_ clknet_leaf_152_clk _01293_ VGND VGND VPWR VPWR cpuregs\[22\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10203_ clknet_leaf_125_clk _00327_ VGND VGND VPWR VPWR cpuregs\[14\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_11183_ clknet_leaf_116_clk _01224_ VGND VGND VPWR VPWR cpuregs\[29\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_10134_ clknet_leaf_74_clk _00258_ VGND VGND VPWR VPWR cpuregs\[28\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_121_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_95_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10065_ clknet_leaf_68_clk _00189_ VGND VGND VPWR VPWR cpuregs\[13\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10967_ clknet_leaf_131_clk _01023_ VGND VGND VPWR VPWR decoded_imm\[7\] sky130_fd_sc_hd__dfxtp_2
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_149_709 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10898_ clknet_leaf_101_clk _00954_ VGND VGND VPWR VPWR mem_state\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_148_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_567 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_152_Right_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold207 cpuregs\[23\]\[12\] VGND VGND VPWR VPWR net1315 sky130_fd_sc_hd__dlygate4sd3_1
Xhold218 cpuregs\[25\]\[30\] VGND VGND VPWR VPWR net1326 sky130_fd_sc_hd__dlygate4sd3_1
X_05040_ net695 net698 net884 VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__o21a_2
Xhold229 cpuregs\[31\]\[4\] VGND VGND VPWR VPWR net1337 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout709 net710 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__clkbuf_4
XFILLER_113_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06991_ reg_pc\[24\] net561 _03401_ net522 VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__a211o_1
XFILLER_85_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05942_ net697 net125 net208 net694 VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__a22o_1
X_08730_ net900 _04411_ _04410_ net659 VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__o211a_1
X_05873_ net858 _01566_ net693 VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__a21o_1
X_08661_ net234 net630 _04349_ _04350_ VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__o22a_1
X_07612_ net1552 net295 net415 VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_121_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08592_ cpuregs\[0\]\[6\] cpuregs\[1\]\[6\] cpuregs\[2\]\[6\] cpuregs\[3\]\[6\] net943
+ net908 VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__mux4_1
XFILLER_26_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07543_ net309 net1988 net423 VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__mux2_1
XFILLER_22_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07474_ net1405 net318 net430 VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__mux2_1
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09213_ decoded_imm\[0\] net552 _04795_ VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__o21a_1
XFILLER_22_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06425_ cpuregs\[0\]\[4\] cpuregs\[1\]\[4\] net787 VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__mux2_1
X_09144_ _04766_ _04771_ net2257 net550 VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_50_898 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06356_ _02787_ _02788_ net649 VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__mux2_1
X_05307_ net703 net343 _01895_ _01899_ VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__a31o_1
X_06287_ _02719_ _02720_ is_lui_auipc_jal VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__a21o_1
X_09075_ net2205 _01619_ _04737_ net2226 VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__a22o_1
XFILLER_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_112_2126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold730 cpuregs\[30\]\[17\] VGND VGND VPWR VPWR net1838 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_79_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05238_ net826 count_cycle\[46\] count_cycle\[14\] net624 _01835_ VGND VGND VPWR
+ VPWR _01836_ sky130_fd_sc_hd__a221o_1
X_08026_ _03842_ _03843_ net976 VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__o21a_1
Xhold763 cpuregs\[7\]\[23\] VGND VGND VPWR VPWR net1871 sky130_fd_sc_hd__dlygate4sd3_1
Xhold741 cpuregs\[6\]\[21\] VGND VGND VPWR VPWR net1849 sky130_fd_sc_hd__dlygate4sd3_1
Xhold752 cpuregs\[5\]\[19\] VGND VGND VPWR VPWR net1860 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold774 cpuregs\[20\]\[27\] VGND VGND VPWR VPWR net1882 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05169_ _01756_ _01759_ _01770_ VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__a21o_1
Xhold796 cpuregs\[24\]\[7\] VGND VGND VPWR VPWR net1904 sky130_fd_sc_hd__dlygate4sd3_1
Xhold785 cpuregs\[22\]\[11\] VGND VGND VPWR VPWR net1893 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_130_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09977_ clknet_leaf_119_clk _00101_ VGND VGND VPWR VPWR cpuregs\[12\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08928_ _04599_ _04601_ _04602_ net892 net898 VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__a221o_1
XFILLER_45_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08859_ _04536_ _04537_ net480 _04534_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__o211a_1
XFILLER_84_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_123_2299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10821_ clknet_leaf_97_clk _00880_ VGND VGND VPWR VPWR instr_srai sky130_fd_sc_hd__dfxtp_1
X_10752_ clknet_leaf_102_clk _00843_ VGND VGND VPWR VPWR latched_is_lb sky130_fd_sc_hd__dfxtp_1
XFILLER_25_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10683_ clknet_leaf_124_clk _00775_ VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dfxtp_1
XFILLER_139_764 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_139_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11304_ clknet_leaf_70_clk _01345_ VGND VGND VPWR VPWR cpuregs\[4\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11235_ clknet_leaf_40_clk _01276_ VGND VGND VPWR VPWR cpuregs\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_113_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11166_ clknet_leaf_28_clk _01207_ VGND VGND VPWR VPWR cpuregs\[23\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_11097_ clknet_leaf_41_clk _01148_ VGND VGND VPWR VPWR cpuregs\[24\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10117_ clknet_leaf_11_clk _00241_ VGND VGND VPWR VPWR cpuregs\[28\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_10048_ clknet_leaf_150_clk _00172_ VGND VGND VPWR VPWR cpuregs\[13\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold90 net64 VGND VGND VPWR VPWR net1198 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_63_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06210_ _02654_ _02657_ net567 VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07190_ net1969 net237 net468 VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__mux2_1
XFILLER_145_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06141_ reg_out\[6\] alu_out_q\[6\] net840 VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__mux2_1
XFILLER_117_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06072_ cpuregs\[0\]\[3\] cpuregs\[1\]\[3\] cpuregs\[2\]\[3\] cpuregs\[3\]\[3\] net954
+ net919 VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__mux4_1
X_09900_ net1142 VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__clkbuf_1
X_05023_ instr_rdcycle net811 net621 _01591_ VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__or4b_1
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_116_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout506 net508 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__buf_2
XFILLER_112_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_98_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout517 _02721_ VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_729 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout539 _02584_ VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__clkbuf_2
Xfanout528 net529 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__clkbuf_2
X_09831_ _02578_ _03565_ VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__or2_4
X_09762_ net245 net2235 net360 VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__mux2_1
X_06974_ _01560_ net511 VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__nand2_1
XFILLER_86_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05925_ net852 net227 net586 _02473_ VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__o22a_1
X_08713_ _04397_ _04399_ net482 _04396_ VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__o211a_1
X_09693_ net1788 net257 net367 VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__mux2_1
XFILLER_54_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05856_ _02051_ net582 net542 _02411_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__o22a_1
X_08644_ cpuregs\[16\]\[9\] cpuregs\[17\]\[9\] cpuregs\[18\]\[9\] cpuregs\[19\]\[9\]
+ net941 net906 VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__mux4_1
XFILLER_82_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05787_ _02152_ _02351_ VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__nand2_1
XFILLER_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08575_ net670 _04268_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__or2_1
XFILLER_42_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07526_ net1338 net238 net428 VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__mux2_1
XFILLER_81_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_651 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07457_ net1542 net250 net437 VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07388_ net258 net2220 net445 VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__mux2_1
XFILLER_136_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06408_ net606 _02834_ _02835_ _02839_ VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__a31o_1
X_09127_ net1203 net548 _04754_ _04765_ VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__a22o_1
X_06339_ net641 _02772_ _02767_ net640 VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__a211o_1
XFILLER_135_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09058_ net662 _04725_ net666 VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_94_1829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_135_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08009_ _03825_ _03827_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__and2_1
Xhold560 cpuregs\[26\]\[22\] VGND VGND VPWR VPWR net1668 sky130_fd_sc_hd__dlygate4sd3_1
Xhold571 cpuregs\[7\]\[16\] VGND VGND VPWR VPWR net1679 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_725 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold582 cpuregs\[31\]\[23\] VGND VGND VPWR VPWR net1690 sky130_fd_sc_hd__dlygate4sd3_1
Xhold593 cpuregs\[5\]\[21\] VGND VGND VPWR VPWR net1701 sky130_fd_sc_hd__dlygate4sd3_1
X_11020_ clknet_leaf_29_clk _01076_ VGND VGND VPWR VPWR cpuregs\[19\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_103_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_89_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_125_2339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1260 instr_bgeu VGND VGND VPWR VPWR net2368 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_57_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1271 reg_pc\[8\] VGND VGND VPWR VPWR net2379 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10804_ clknet_leaf_96_clk _00863_ VGND VGND VPWR VPWR instr_sltiu sky130_fd_sc_hd__dfxtp_1
XFILLER_14_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10735_ clknet_leaf_56_clk _00826_ VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dfxtp_2
XFILLER_15_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10666_ clknet_leaf_93_clk _04890_ VGND VGND VPWR VPWR reg_out\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10597_ clknet_leaf_104_clk _00721_ VGND VGND VPWR VPWR count_cycle\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_153_2793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput109 net109 VGND VGND VPWR VPWR mem_la_wdata[20] sky130_fd_sc_hd__buf_2
XFILLER_114_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_141_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11218_ clknet_leaf_149_clk _01259_ VGND VGND VPWR VPWR cpuregs\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xoutput80 net80 VGND VGND VPWR VPWR mem_la_addr[24] sky130_fd_sc_hd__buf_2
XFILLER_150_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_612 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput91 net91 VGND VGND VPWR VPWR mem_la_addr[5] sky130_fd_sc_hd__buf_2
X_11149_ clknet_leaf_138_clk _01190_ VGND VGND VPWR VPWR cpuregs\[23\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_95_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_110_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06690_ _03107_ _03108_ net647 VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__mux2_1
XFILLER_64_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05710_ _02191_ _02283_ net692 VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05641_ _02054_ _02213_ _02220_ VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_19_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08360_ _04120_ _04121_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__nor2_1
XFILLER_23_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07311_ net1901 net298 net451 VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__mux2_1
X_05572_ _02150_ _02151_ VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__nor2_1
XFILLER_149_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08291_ count_cycle\[10\] _04075_ count_cycle\[11\] VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__a21o_1
XFILLER_20_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07242_ net1380 net314 net459 VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__mux2_1
XFILLER_118_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07173_ net1961 net310 net466 VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__mux2_1
XFILLER_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06124_ net531 net1556 net477 VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__mux2_1
XFILLER_118_789 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06055_ net665 _02520_ _02524_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__a21oi_1
XFILLER_99_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout314 net315 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__buf_2
Xfanout303 _02740_ VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_4
X_05006_ reg_sh\[4\] _01624_ VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__or2_2
XFILLER_143_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout347 _04879_ VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_8
X_09814_ net301 net1839 net350 VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__mux2_1
Xfanout325 _02620_ VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__buf_2
Xfanout336 net338 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__clkbuf_2
XFILLER_101_656 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout358 _04876_ VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__buf_4
Xfanout369 net372 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__clkbuf_8
X_06957_ _03365_ _03366_ net654 VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_2036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_378 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09745_ net316 net1812 net357 VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_2047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05908_ _02080_ net577 net586 VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__a21oi_1
X_06888_ _03277_ _03300_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__nor2_1
X_09676_ net1424 net326 net365 VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05839_ _02064_ net585 net580 _02065_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__a22o_1
X_08627_ cpuregs\[28\]\[8\] cpuregs\[29\]\[8\] cpuregs\[30\]\[8\] cpuregs\[31\]\[8\]
+ net944 net909 VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__mux4_1
XFILLER_43_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_120_2247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08558_ decoded_imm\[2\] _02536_ net601 VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__mux2_1
X_08489_ net73 net1225 net408 VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__mux2_1
X_07509_ net1630 net310 net427 VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__mux2_1
XFILLER_52_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10520_ clknet_leaf_81_clk _00644_ VGND VGND VPWR VPWR count_instr\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10451_ clknet_leaf_67_clk _00575_ VGND VGND VPWR VPWR cpuregs\[17\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10382_ clknet_leaf_42_clk _00506_ VGND VGND VPWR VPWR cpuregs\[25\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_135_2490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_124_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold390 cpuregs\[20\]\[25\] VGND VGND VPWR VPWR net1498 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_78_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11003_ clknet_leaf_72_clk _01059_ VGND VGND VPWR VPWR cpuregs\[18\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_132_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout870 net178 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__buf_2
XFILLER_77_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout892 net893 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__buf_4
XFILLER_46_710 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout881 net197 VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__clkbuf_4
XFILLER_133_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1090 cpuregs\[9\]\[12\] VGND VGND VPWR VPWR net2198 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_34_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10718_ clknet_leaf_132_clk _00809_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dfxtp_4
X_10649_ clknet_leaf_130_clk _04892_ VGND VGND VPWR VPWR reg_out\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_39_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_69_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07860_ reg_pc\[12\] net503 _03708_ net602 VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__a22o_1
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_110_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06811_ cpuregs\[4\]\[18\] cpuregs\[5\]\[18\] cpuregs\[6\]\[18\] cpuregs\[7\]\[18\]
+ net792 net755 VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__mux4_1
XFILLER_83_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07791_ net2252 _03666_ net988 VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__o21ai_1
X_09530_ net1268 net244 net388 VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__mux2_1
XFILLER_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06742_ net871 _03161_ net306 VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__mux2_1
X_09461_ net255 net2229 net395 VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__mux2_1
X_06673_ _03064_ _03069_ _03093_ net609 VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__a31o_1
XFILLER_64_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08412_ count_cycle\[55\] _04151_ count_cycle\[56\] VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__a21o_1
X_05624_ _02149_ _02201_ _02203_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__a21oi_1
XFILLER_52_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_52_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09392_ mem_rdata_q\[23\] _04794_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__and2_1
XFILLER_149_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08343_ net2312 _04109_ net993 VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__o21ai_1
X_05555_ _02133_ _02134_ VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__nand2_2
XFILLER_149_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08274_ net2264 _04065_ _04067_ VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__a21oi_1
X_07225_ net1600 net242 net464 VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__mux2_1
X_05486_ _02063_ _02065_ VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__nor2_2
XFILLER_22_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_138_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_152_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07156_ latched_rd\[2\] latched_rd\[3\] latched_rd\[4\] VGND VGND VPWR VPWR _03560_
+ sky130_fd_sc_hd__or3_2
XFILLER_118_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_105_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07087_ net526 _03492_ _03493_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__or3_1
X_06107_ net896 _02573_ _02574_ VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__a21oi_1
XFILLER_133_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_105_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06038_ decoded_imm_j\[16\] _01110_ net333 VGND VGND VPWR VPWR _00033_ sky130_fd_sc_hd__mux2_1
XFILLER_121_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_87_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09728_ net247 net2059 net364 VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__mux2_1
XFILLER_75_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07989_ _03805_ _03808_ net832 VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__o21ai_1
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_90_819 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09659_ net255 net2069 net370 VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__mux2_1
XFILLER_83_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_151_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_2530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10503_ clknet_leaf_105_clk _00627_ VGND VGND VPWR VPWR count_instr\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11483_ clknet_leaf_4_clk _01521_ VGND VGND VPWR VPWR cpuregs\[10\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_150_2730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_109_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10434_ clknet_leaf_13_clk _00558_ VGND VGND VPWR VPWR cpuregs\[17\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_137_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10365_ clknet_leaf_142_clk _00489_ VGND VGND VPWR VPWR cpuregs\[25\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10296_ clknet_leaf_137_clk _00420_ VGND VGND VPWR VPWR cpuregs\[26\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_148_2692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_773 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_827 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_66_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_646 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_93_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05340_ net15 net597 net587 VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_147_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05271_ count_instr\[16\] net821 net624 _01866_ VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__a211o_1
X_07010_ cpuregs\[16\]\[25\] cpuregs\[17\]\[25\] cpuregs\[18\]\[25\] cpuregs\[19\]\[25\]
+ net803 net766 VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__mux4_1
XFILLER_134_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_143_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_47_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_143_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08961_ cpuregs\[12\]\[26\] cpuregs\[13\]\[26\] cpuregs\[14\]\[26\] cpuregs\[15\]\[26\]
+ net969 net934 VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__mux4_1
XFILLER_142_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_103_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08892_ net679 _04560_ net897 VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__o21a_1
XFILLER_124_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07912_ decoded_imm_j\[3\] _03699_ VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__or2_1
XFILLER_69_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_68_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07843_ _02592_ reg_next_pc\[4\] net570 VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__mux2_2
XFILLER_110_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04986_ _01547_ _01610_ _01609_ VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__a21oi_1
X_07774_ count_instr\[41\] count_instr\[40\] count_instr\[39\] _03652_ VGND VGND VPWR
+ VPWR _03657_ sky130_fd_sc_hd__and4_1
XFILLER_56_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_83_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06725_ net173 net510 net489 _03144_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__o211a_1
X_09513_ net1545 net319 net385 VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_84_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06656_ cpuregs\[4\]\[12\] cpuregs\[5\]\[12\] cpuregs\[6\]\[12\] cpuregs\[7\]\[12\]
+ net778 net742 VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__mux4_1
X_09444_ net326 net1887 net393 VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05607_ net882 _01563_ _02186_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__o21a_1
XFILLER_33_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06587_ decoded_imm\[10\] net875 VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__nand2_1
X_09375_ net810 mem_rdata_q\[7\] decoded_imm_j\[11\] net833 net551 VGND VGND VPWR
+ VPWR _04850_ sky130_fd_sc_hd__a221o_1
XFILLER_40_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08326_ count_cycle\[22\] count_cycle\[23\] count_cycle\[24\] _04095_ VGND VGND VPWR
+ VPWR _04100_ sky130_fd_sc_hd__and4_1
X_05538_ _02117_ VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__inv_2
X_08257_ net814 _03727_ _04046_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__a21oi_1
X_05469_ net868 net211 VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__nand2_1
XFILLER_20_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08188_ _03988_ _03991_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__nor2_1
X_07208_ net1977 net315 net463 VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__mux2_1
XFILLER_4_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07139_ cpuregs\[8\]\[30\] cpuregs\[9\]\[30\] cpuregs\[10\]\[30\] cpuregs\[11\]\[30\]
+ net807 net770 VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_115_2179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_2168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_106_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10150_ clknet_leaf_9_clk _00274_ VGND VGND VPWR VPWR cpuregs\[21\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10081_ clknet_leaf_0_clk _00205_ VGND VGND VPWR VPWR cpuregs\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_87_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_148_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_148_clk sky130_fd_sc_hd__clkbuf_8
X_10983_ clknet_leaf_1_clk _01039_ VGND VGND VPWR VPWR cpuregs\[18\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_28_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_790 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_129_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_139_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11466_ clknet_leaf_49_clk _01504_ VGND VGND VPWR VPWR cpuregs\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10417_ clknet_leaf_66_clk _00541_ VGND VGND VPWR VPWR cpuregs\[20\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11397_ clknet_leaf_38_clk _01435_ VGND VGND VPWR VPWR cpuregs\[7\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_151_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10348_ clknet_leaf_34_clk _00472_ VGND VGND VPWR VPWR cpuregs\[16\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_10279_ clknet_leaf_17_clk _00403_ VGND VGND VPWR VPWR cpuregs\[15\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_139_clk clknet_4_2_0_clk VGND VGND VPWR VPWR clknet_leaf_139_clk sky130_fd_sc_hd__clkbuf_8
X_07490_ net1870 net247 net433 VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__mux2_1
XFILLER_80_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06510_ _02936_ _02937_ VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_66_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1007 VGND VGND VPWR VPWR picorv32_1007/HI eoi[4] sky130_fd_sc_hd__conb_1
X_06441_ net882 net880 net506 VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__mux2_1
Xpicorv32_1029 VGND VGND VPWR VPWR picorv32_1029/HI eoi[26] sky130_fd_sc_hd__conb_1
Xpicorv32_1018 VGND VGND VPWR VPWR picorv32_1018/HI eoi[15] sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09160_ net2341 net500 _04757_ _04773_ VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__a22o_1
X_06372_ _02804_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__inv_2
X_05323_ reg_pc\[21\] decoded_imm\[21\] VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__nand2_1
X_08111_ _03895_ _03909_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__nand2_1
X_09091_ net332 _01100_ _04743_ VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__and3_1
XFILLER_30_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08042_ decoded_imm_j\[14\] _03710_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__and2_1
X_05254_ count_instr\[15\] net821 net624 _01850_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__a211o_1
Xhold912 cpuregs\[21\]\[30\] VGND VGND VPWR VPWR net2020 sky130_fd_sc_hd__dlygate4sd3_1
Xhold901 cpuregs\[16\]\[7\] VGND VGND VPWR VPWR net2009 sky130_fd_sc_hd__dlygate4sd3_1
Xhold923 cpuregs\[3\]\[20\] VGND VGND VPWR VPWR net2031 sky130_fd_sc_hd__dlygate4sd3_1
X_05185_ net824 count_cycle\[42\] count_cycle\[10\] net625 _01786_ VGND VGND VPWR
+ VPWR _01787_ sky130_fd_sc_hd__a221o_1
Xhold934 cpuregs\[17\]\[5\] VGND VGND VPWR VPWR net2042 sky130_fd_sc_hd__dlygate4sd3_1
Xhold945 cpuregs\[30\]\[5\] VGND VGND VPWR VPWR net2053 sky130_fd_sc_hd__dlygate4sd3_1
Xhold956 cpuregs\[18\]\[16\] VGND VGND VPWR VPWR net2064 sky130_fd_sc_hd__dlygate4sd3_1
Xhold967 cpuregs\[8\]\[17\] VGND VGND VPWR VPWR net2075 sky130_fd_sc_hd__dlygate4sd3_1
X_09993_ clknet_leaf_25_clk _00117_ VGND VGND VPWR VPWR cpuregs\[12\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold978 cpuregs\[7\]\[12\] VGND VGND VPWR VPWR net2086 sky130_fd_sc_hd__dlygate4sd3_1
Xhold989 cpuregs\[6\]\[5\] VGND VGND VPWR VPWR net2097 sky130_fd_sc_hd__dlygate4sd3_1
X_08944_ cpuregs\[8\]\[25\] cpuregs\[9\]\[25\] cpuregs\[10\]\[25\] cpuregs\[11\]\[25\]
+ net970 net935 VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__mux4_1
XFILLER_135_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_2098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08875_ _04543_ _04544_ net679 VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__mux2_1
XFILLER_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_151_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07826_ net2287 _03687_ _03689_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_86_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04969_ net984 _01593_ _01594_ VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__a21oi_1
XFILLER_56_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07757_ _03646_ net980 _03645_ VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__and3b_1
X_06708_ cpuregs\[20\]\[14\] cpuregs\[21\]\[14\] cpuregs\[22\]\[14\] cpuregs\[23\]\[14\]
+ net780 net744 VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__mux4_1
XFILLER_71_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07688_ _03602_ net985 _03601_ VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__and3b_1
X_09427_ net259 net1954 net399 VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__mux2_1
X_06639_ net305 _03048_ _03062_ _03039_ VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__a31o_1
XFILLER_12_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09358_ net838 decoded_imm_j\[19\] net616 mem_rdata_q\[19\] VGND VGND VPWR VPWR _04841_
+ sky130_fd_sc_hd__a22o_1
XFILLER_138_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_2208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08309_ _04089_ net994 _04088_ VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__and3b_1
XFILLER_21_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_126_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09289_ net1174 net102 net485 VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__mux2_1
X_11320_ clknet_leaf_5_clk _01361_ VGND VGND VPWR VPWR cpuregs\[5\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_130_2408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_130_2419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_118_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_107_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11251_ clknet_leaf_146_clk _01292_ VGND VGND VPWR VPWR cpuregs\[22\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11182_ clknet_leaf_114_clk _01223_ VGND VGND VPWR VPWR cpuregs\[29\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_10202_ clknet_leaf_115_clk _00326_ VGND VGND VPWR VPWR cpuregs\[14\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_10133_ clknet_leaf_79_clk _00257_ VGND VGND VPWR VPWR cpuregs\[28\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_121_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10064_ clknet_leaf_51_clk _00188_ VGND VGND VPWR VPWR cpuregs\[13\]\[24\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_50_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10966_ clknet_leaf_131_clk _01022_ VGND VGND VPWR VPWR decoded_imm\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10897_ clknet_4_10_0_clk _00953_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dfxtp_1
XFILLER_8_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold208 cpuregs\[31\]\[6\] VGND VGND VPWR VPWR net1316 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold219 cpuregs\[27\]\[29\] VGND VGND VPWR VPWR net1327 sky130_fd_sc_hd__dlygate4sd3_1
X_11449_ clknet_leaf_0_clk _01487_ VGND VGND VPWR VPWR cpuregs\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_140_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06990_ net724 _03400_ _03399_ net518 VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__o211a_1
X_05941_ net696 net845 net207 net593 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__a22o_1
XFILLER_66_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05872_ _02092_ _02420_ VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__and2_1
X_08660_ decoded_imm\[9\] net600 net626 VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__a21o_1
XFILLER_38_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_93_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07611_ net1696 net300 net415 VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08591_ cpuregs\[4\]\[6\] cpuregs\[5\]\[6\] cpuregs\[6\]\[6\] cpuregs\[7\]\[6\] net943
+ net908 VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__mux4_1
XFILLER_35_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07542_ net313 net2137 net422 VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__mux2_1
XFILLER_53_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07473_ net1255 net320 net430 VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__mux2_1
X_09212_ is_sb_sh_sw mem_rdata_q\[7\] _04794_ mem_rdata_q\[20\] net551 VGND VGND VPWR
+ VPWR _04795_ sky130_fd_sc_hd__a221o_1
XFILLER_50_855 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06424_ _02854_ net751 VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__nand2b_1
X_09143_ _04753_ _04769_ _04770_ VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__or3_1
X_06355_ cpuregs\[0\]\[2\] cpuregs\[1\]\[2\] cpuregs\[2\]\[2\] cpuregs\[3\]\[2\] net789
+ net752 VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__mux4_1
XFILLER_148_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05306_ net590 _01897_ _01898_ net866 net708 VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__a32o_1
X_06286_ net564 _02720_ is_lui_auipc_jal VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__a21oi_4
X_09074_ instr_lh _01619_ _04737_ net2254 VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__a22o_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_146_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_2127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_2116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05237_ count_instr\[46\] net817 net821 count_instr\[14\] VGND VGND VPWR VPWR _01835_
+ sky130_fd_sc_hd__a22o_1
X_08025_ net688 reg_next_pc\[12\] net545 _03708_ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__a22o_1
Xhold720 cpuregs\[5\]\[2\] VGND VGND VPWR VPWR net1828 sky130_fd_sc_hd__dlygate4sd3_1
Xhold742 cpuregs\[7\]\[30\] VGND VGND VPWR VPWR net1850 sky130_fd_sc_hd__dlygate4sd3_1
Xhold753 cpuregs\[10\]\[24\] VGND VGND VPWR VPWR net1861 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_104_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold731 cpuregs\[8\]\[15\] VGND VGND VPWR VPWR net1839 sky130_fd_sc_hd__dlygate4sd3_1
X_05168_ _01756_ _01759_ _01770_ VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__nand3_1
Xhold764 cpuregs\[18\]\[11\] VGND VGND VPWR VPWR net1872 sky130_fd_sc_hd__dlygate4sd3_1
Xhold786 cpuregs\[28\]\[23\] VGND VGND VPWR VPWR net1894 sky130_fd_sc_hd__dlygate4sd3_1
Xhold797 cpuregs\[12\]\[20\] VGND VGND VPWR VPWR net1905 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_89_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold775 cpuregs\[10\]\[12\] VGND VGND VPWR VPWR net1883 sky130_fd_sc_hd__dlygate4sd3_1
X_09976_ clknet_leaf_137_clk _00100_ VGND VGND VPWR VPWR cpuregs\[12\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_05099_ _01705_ _01706_ net711 VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__and3b_1
X_08927_ _04591_ _04592_ net680 VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__mux2_1
XFILLER_103_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_130_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08858_ net892 _04535_ net666 VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__a21o_1
XFILLER_29_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_127_2370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07809_ count_instr\[54\] _03677_ net998 VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__o21ai_1
XFILLER_85_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08789_ _04470_ _04471_ net480 _04468_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__o211a_1
XFILLER_72_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10820_ clknet_leaf_97_clk _00879_ VGND VGND VPWR VPWR instr_and sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_140_2570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10751_ clknet_leaf_101_clk net2255 VGND VGND VPWR VPWR latched_is_lh sky130_fd_sc_hd__dfxtp_1
X_10682_ clknet_leaf_124_clk _00774_ VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dfxtp_1
XFILLER_139_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_138_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_126_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11303_ clknet_leaf_49_clk _01344_ VGND VGND VPWR VPWR cpuregs\[4\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_126_448 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11234_ clknet_leaf_38_clk _01275_ VGND VGND VPWR VPWR cpuregs\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_122_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11165_ clknet_leaf_44_clk _01206_ VGND VGND VPWR VPWR cpuregs\[23\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_11096_ clknet_leaf_44_clk _01147_ VGND VGND VPWR VPWR cpuregs\[24\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_110_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10116_ clknet_leaf_12_clk _00240_ VGND VGND VPWR VPWR cpuregs\[28\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10047_ clknet_leaf_152_clk _00171_ VGND VGND VPWR VPWR cpuregs\[13\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold91 cpuregs\[1\]\[30\] VGND VGND VPWR VPWR net1199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 decoded_rd\[1\] VGND VGND VPWR VPWR net1188 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_17_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_800 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10949_ clknet_leaf_93_clk _01005_ VGND VGND VPWR VPWR decoded_imm\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_63_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_70_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_70_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_63_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06140_ net474 net1692 net476 VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__mux2_1
XFILLER_144_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06071_ cpuregs\[4\]\[3\] cpuregs\[5\]\[3\] cpuregs\[6\]\[3\] cpuregs\[7\]\[3\] net954
+ net919 VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__mux4_1
X_05022_ is_jalr_addi_slti_sltiu_xori_ori_andi is_lui_auipc_jal VGND VGND VPWR VPWR
+ _01640_ sky130_fd_sc_hd__or2_2
XPHY_EDGE_ROW_20_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_144_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09830_ _02708_ net2027 net351 VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__mux2_1
XFILLER_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout518 _02721_ VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__buf_4
Xfanout507 net508 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_59_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout529 _02591_ VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__buf_2
X_09761_ net247 net1995 net360 VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__mux2_1
XFILLER_112_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06973_ net607 _03382_ _03383_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_91_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_112_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05924_ net852 net227 _02245_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__a21oi_1
XFILLER_100_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08712_ net890 _04398_ net664 VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__a21o_1
XFILLER_39_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09692_ net1555 net262 net368 VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__mux2_1
XFILLER_132_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05855_ _02051_ net576 net585 VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__a21oi_1
XFILLER_82_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08643_ cpuregs\[20\]\[9\] cpuregs\[21\]\[9\] cpuregs\[22\]\[9\] cpuregs\[23\]\[9\]
+ net942 net907 VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__mux4_1
X_05786_ net829 _02146_ _02350_ _02349_ VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__o31a_1
XFILLER_25_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08574_ cpuregs\[12\]\[5\] cpuregs\[13\]\[5\] cpuregs\[14\]\[5\] cpuregs\[15\]\[5\]
+ net945 net910 VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__mux4_1
X_07525_ net1551 net239 net429 VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__mux2_1
XFILLER_81_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_61_clk clknet_4_12_0_clk VGND VGND VPWR VPWR clknet_leaf_61_clk sky130_fd_sc_hd__clkbuf_8
X_07456_ net1548 net251 net437 VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__mux2_1
XFILLER_23_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07387_ net262 net2186 net445 VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06407_ reg_pc\[3\] net526 net563 _02837_ _02838_ VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__a32o_1
X_09126_ is_lb_lh_lw_lbu_lhu net555 VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__and2_1
X_06338_ _02769_ _02771_ _02768_ _02770_ net734 net752 VGND VGND VPWR VPWR _02772_
+ sky130_fd_sc_hd__mux4_1
X_06269_ net240 net2115 net479 VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__mux2_1
X_09057_ _04719_ _04720_ net677 VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__mux2_1
XFILLER_108_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08008_ _03809_ _03826_ _03816_ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__o21a_1
Xhold550 cpuregs\[24\]\[30\] VGND VGND VPWR VPWR net1658 sky130_fd_sc_hd__dlygate4sd3_1
Xhold561 cpuregs\[28\]\[15\] VGND VGND VPWR VPWR net1669 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_737 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold572 cpuregs\[10\]\[6\] VGND VGND VPWR VPWR net1680 sky130_fd_sc_hd__dlygate4sd3_1
Xhold594 cpuregs\[27\]\[30\] VGND VGND VPWR VPWR net1702 sky130_fd_sc_hd__dlygate4sd3_1
Xhold583 cpuregs\[28\]\[31\] VGND VGND VPWR VPWR net1691 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_106_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_104_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09959_ clknet_leaf_19_clk _00083_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dfxtp_2
XFILLER_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_142_2610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_2329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1261 decoded_imm\[26\] VGND VGND VPWR VPWR net2369 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1250 decoded_imm_j\[10\] VGND VGND VPWR VPWR net2358 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_66_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10803_ clknet_leaf_96_clk _00862_ VGND VGND VPWR VPWR instr_slti sky130_fd_sc_hd__dfxtp_1
XFILLER_32_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_52_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_52_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_45_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10734_ clknet_leaf_20_clk _00825_ VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dfxtp_2
XFILLER_15_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10665_ clknet_leaf_60_clk _04889_ VGND VGND VPWR VPWR reg_out\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10596_ clknet_leaf_104_clk _00720_ VGND VGND VPWR VPWR count_cycle\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_153_2794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput70 net70 VGND VGND VPWR VPWR mem_la_addr[14] sky130_fd_sc_hd__buf_2
XFILLER_141_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11217_ clknet_leaf_142_clk _01258_ VGND VGND VPWR VPWR cpuregs\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xoutput81 net81 VGND VGND VPWR VPWR mem_la_addr[25] sky130_fd_sc_hd__buf_2
XFILLER_150_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_110_624 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11148_ clknet_leaf_24_clk _01189_ VGND VGND VPWR VPWR cpuregs\[31\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xoutput92 net92 VGND VGND VPWR VPWR mem_la_addr[6] sky130_fd_sc_hd__buf_2
X_11079_ clknet_leaf_128_clk _01130_ VGND VGND VPWR VPWR cpuregs\[24\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_05640_ _02054_ _02058_ _02212_ _02214_ _02219_ VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__a311o_1
XFILLER_64_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_574 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05571_ net871 net209 VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__nor2_1
XFILLER_51_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_43_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_43_clk sky130_fd_sc_hd__clkbuf_8
X_07310_ net1669 net301 net450 VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__mux2_1
XFILLER_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08290_ net2298 _04075_ _04077_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__a21oi_1
XFILLER_20_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_674 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07241_ net1364 net318 net458 VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__mux2_1
X_07172_ net1666 net314 net467 VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__mux2_1
XFILLER_20_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06123_ _02587_ _01550_ net566 VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_76_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_105_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06054_ net896 _02523_ net891 VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__a21o_1
Xfanout304 net305 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__clkbuf_4
X_05005_ reg_sh\[4\] _01624_ VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__nor2_2
Xfanout348 _04879_ VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkbuf_4
XFILLER_100_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09813_ net310 net1983 net349 VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__mux2_1
Xfanout315 _02634_ VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_538 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout326 net329 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__clkbuf_2
Xfanout337 net338 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__clkbuf_2
XFILLER_143_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_140_270 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout359 net360 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkbuf_8
X_06956_ cpuregs\[16\]\[23\] cpuregs\[17\]\[23\] cpuregs\[18\]\[23\] cpuregs\[19\]\[23\]
+ net800 net763 VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__mux4_1
XFILLER_101_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_101_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09744_ net320 net2146 net357 VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_2048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05907_ _02082_ _02457_ VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__xnor2_1
X_06887_ _03272_ _03275_ _03299_ _03274_ VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__a211o_1
XFILLER_54_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09675_ net1395 net335 net365 VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__mux2_1
XFILLER_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05838_ _02066_ _02395_ _02396_ net542 VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__a211oi_1
XFILLER_82_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08626_ net899 _04316_ VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_38_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_120_2259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_2248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_34_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_34_clk sky130_fd_sc_hd__clkbuf_8
X_05769_ net828 _02157_ _02335_ _02334_ VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__o31a_1
XFILLER_35_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08557_ _01562_ net631 _04254_ VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__o21ai_1
X_08488_ net72 net1171 net409 VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__mux2_1
X_07508_ net1592 net315 net426 VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_102_1970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07439_ net1533 net325 net434 VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__mux2_1
XFILLER_10_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10450_ clknet_leaf_48_clk _00574_ VGND VGND VPWR VPWR cpuregs\[17\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09109_ net2242 net500 _04750_ _04756_ VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_135_2491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10381_ clknet_leaf_43_clk _00505_ VGND VGND VPWR VPWR cpuregs\[25\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_124_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold380 cpuregs\[15\]\[26\] VGND VGND VPWR VPWR net1488 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_151_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_77_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11002_ clknet_leaf_73_clk _01058_ VGND VGND VPWR VPWR cpuregs\[18\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_132_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold391 cpuregs\[13\]\[8\] VGND VGND VPWR VPWR net1499 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_131_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout860 net186 VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__clkbuf_4
XFILLER_93_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout871 net177 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__buf_2
Xfanout893 net894 VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__buf_4
Xfanout882 net196 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__buf_2
XFILLER_46_722 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1091 cpuregs\[16\]\[29\] VGND VGND VPWR VPWR net2199 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_93_43 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1080 cpuregs\[8\]\[10\] VGND VGND VPWR VPWR net2188 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_25_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_26_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10717_ clknet_leaf_127_clk _00808_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dfxtp_2
XFILLER_146_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10648_ clknet_leaf_101_clk _04881_ VGND VGND VPWR VPWR reg_out\[0\] sky130_fd_sc_hd__dfxtp_1
X_10579_ clknet_leaf_74_clk _00703_ VGND VGND VPWR VPWR reg_next_pc\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_115_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_115_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_313 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_96_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_95_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_95_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_96_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06810_ net872 net509 net489 _03226_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__o211a_1
X_07790_ count_instr\[47\] count_instr\[46\] count_instr\[45\] _03662_ VGND VGND VPWR
+ VPWR _03667_ sky130_fd_sc_hd__and4_1
XFILLER_56_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_147_Right_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06741_ net524 _03143_ _03145_ _03146_ _03160_ VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__o41a_1
X_09460_ net259 net2215 net395 VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__mux2_1
X_08411_ net2268 _04151_ _04153_ VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__a21oi_1
X_06672_ _03064_ _03069_ _03093_ VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__a21o_1
XFILLER_24_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05623_ net208 net872 VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__and2b_1
Xclkbuf_leaf_16_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_51_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09391_ decoded_imm\[4\] net552 _04857_ _04858_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__o22a_1
X_08342_ count_cycle\[28\] count_cycle\[29\] count_cycle\[30\] _04105_ VGND VGND VPWR
+ VPWR _04110_ sky130_fd_sc_hd__and4_2
X_05554_ net877 net233 VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__or2_1
X_05485_ net862 net216 VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__and2_1
X_08273_ count_cycle\[4\] _04065_ net982 VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__o21ai_1
X_07224_ net1218 net243 net464 VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__mux2_1
XFILLER_118_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_576 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07155_ latched_rd\[4\] latched_rd\[3\] latched_rd\[2\] VGND VGND VPWR VPWR _03559_
+ sky130_fd_sc_hd__nand3b_4
X_07086_ net855 net511 _03411_ net498 VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__o211a_1
X_06106_ net668 _02570_ net660 VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__a21o_1
X_06037_ mem_rdata_q\[16\] net8 net613 VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__mux2_1
XFILLER_114_771 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_99_482 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_101_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_86_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07988_ _03782_ _03806_ _03807_ _03794_ _03805_ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__o2111a_1
XFILLER_47_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09727_ net253 net1769 net364 VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06939_ decoded_imm\[23\] net859 VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__or2_1
XFILLER_47_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_90_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09658_ net259 net1965 net371 VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__mux2_1
X_09589_ net2025 net273 net378 VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__mux2_1
XFILLER_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08609_ cpuregs\[24\]\[7\] cpuregs\[25\]\[7\] cpuregs\[26\]\[7\] cpuregs\[27\]\[7\]
+ net943 net908 VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__mux4_1
XFILLER_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_144_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_137_2520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10502_ clknet_leaf_105_clk _00626_ VGND VGND VPWR VPWR count_instr\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11482_ clknet_leaf_15_clk _01520_ VGND VGND VPWR VPWR cpuregs\[10\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_150_2731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10433_ clknet_leaf_1_clk _00557_ VGND VGND VPWR VPWR cpuregs\[17\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10364_ clknet_leaf_128_clk _00488_ VGND VGND VPWR VPWR cpuregs\[25\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_3_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_152_899 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10295_ clknet_leaf_35_clk _00419_ VGND VGND VPWR VPWR cpuregs\[15\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_105_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout690 net691 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__buf_4
XFILLER_78_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_93_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_371 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_61_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_29_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05270_ count_instr\[48\] net817 net826 count_cycle\[48\] VGND VGND VPWR VPWR _01866_
+ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_40_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_143_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_143_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08960_ cpuregs\[0\]\[26\] cpuregs\[1\]\[26\] cpuregs\[2\]\[26\] cpuregs\[3\]\[26\]
+ net966 net931 VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__mux4_1
XFILLER_102_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_5_clk clknet_4_0_0_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_08891_ _04565_ _04566_ net679 VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__mux2_1
XFILLER_124_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07911_ decoded_imm_j\[3\] _03699_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__nand2_1
X_07842_ reg_pc\[3\] net502 _03699_ net602 VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__a22o_1
XFILLER_111_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_83_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04985_ instr_lhu instr_lw instr_lh _01578_ VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__or4_1
X_07773_ _03656_ net986 _03655_ VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_3_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09512_ net1248 net322 net385 VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__mux2_1
XFILLER_140_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06724_ net865 net514 VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__or2_1
XFILLER_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_80_831 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06655_ cpuregs\[24\]\[12\] cpuregs\[25\]\[12\] cpuregs\[26\]\[12\] cpuregs\[27\]\[12\]
+ net779 net743 VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__mux4_1
XFILLER_13_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09443_ net336 net1721 net393 VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__mux2_1
XFILLER_80_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09374_ is_sb_sh_sw _04794_ mem_rdata_q\[31\] VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__o21a_1
XFILLER_52_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05606_ net882 _01563_ _02129_ _02185_ _02183_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__a221o_1
X_08325_ _04099_ net992 _04098_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__and3b_1
X_06586_ decoded_imm\[10\] net875 VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__or2_1
XFILLER_33_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05537_ net173 net205 VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__nand2_1
XFILLER_137_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_119_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08256_ _03728_ _04049_ net838 VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__a21oi_1
X_05468_ net868 net211 VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__and2_1
X_08187_ _03988_ _03991_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__and2_1
X_07207_ net1345 net318 net462 VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__mux2_1
XFILLER_134_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_132_2450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07138_ cpuregs\[12\]\[30\] cpuregs\[13\]\[30\] cpuregs\[14\]\[30\] cpuregs\[15\]\[30\]
+ net807 net770 VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_115_2169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05399_ net715 _01977_ _01978_ _01984_ VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__a31o_1
XFILLER_106_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07069_ _03474_ _03476_ _03473_ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__o21a_1
XFILLER_121_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_121_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_99_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10080_ clknet_leaf_3_clk _00204_ VGND VGND VPWR VPWR cpuregs\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_828 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_74_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_63_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10982_ clknet_leaf_3_clk _01038_ VGND VGND VPWR VPWR cpuregs\[18\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_70_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_71_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11465_ clknet_leaf_68_clk _01503_ VGND VGND VPWR VPWR cpuregs\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_139_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10416_ clknet_leaf_57_clk _00540_ VGND VGND VPWR VPWR cpuregs\[20\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_7_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11396_ clknet_leaf_37_clk _01434_ VGND VGND VPWR VPWR cpuregs\[7\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_112_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10347_ clknet_leaf_20_clk _00471_ VGND VGND VPWR VPWR cpuregs\[16\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10278_ clknet_leaf_28_clk _00402_ VGND VGND VPWR VPWR cpuregs\[15\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06440_ net877 net515 VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__or2_1
Xpicorv32_1008 VGND VGND VPWR VPWR picorv32_1008/HI eoi[5] sky130_fd_sc_hd__conb_1
Xpicorv32_1019 VGND VGND VPWR VPWR picorv32_1019/HI eoi[16] sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_66_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06371_ decoded_imm\[2\] net883 VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__nand2_1
X_05322_ reg_pc\[21\] decoded_imm\[21\] VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__nor2_1
X_08110_ _03919_ _03920_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__nor2_1
X_09090_ _04741_ _01098_ VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__nor2_1
XFILLER_119_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05253_ count_instr\[47\] net817 net826 count_cycle\[47\] VGND VGND VPWR VPWR _01850_
+ sky130_fd_sc_hd__a22o_1
X_08041_ _03856_ _03857_ net976 VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__o21a_1
XFILLER_134_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold902 cpuregs\[20\]\[0\] VGND VGND VPWR VPWR net2010 sky130_fd_sc_hd__dlygate4sd3_1
Xhold913 cpuregs\[23\]\[8\] VGND VGND VPWR VPWR net2021 sky130_fd_sc_hd__dlygate4sd3_1
Xhold946 cpuregs\[12\]\[21\] VGND VGND VPWR VPWR net2054 sky130_fd_sc_hd__dlygate4sd3_1
Xhold935 cpuregs\[16\]\[24\] VGND VGND VPWR VPWR net2043 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_115_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold924 cpuregs\[7\]\[14\] VGND VGND VPWR VPWR net2032 sky130_fd_sc_hd__dlygate4sd3_1
X_05184_ count_instr\[42\] net815 net820 count_instr\[10\] VGND VGND VPWR VPWR _01786_
+ sky130_fd_sc_hd__a22o_1
X_09992_ clknet_leaf_54_clk _00116_ VGND VGND VPWR VPWR cpuregs\[12\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold957 cpuregs\[19\]\[31\] VGND VGND VPWR VPWR net2065 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold979 cpuregs\[11\]\[19\] VGND VGND VPWR VPWR net2087 sky130_fd_sc_hd__dlygate4sd3_1
Xhold968 cpuregs\[2\]\[1\] VGND VGND VPWR VPWR net2076 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08943_ net683 _04616_ VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__or2_1
XFILLER_103_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_110_2099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_2088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08874_ _04541_ _04550_ _04551_ net661 net897 VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__a221o_1
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_151_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07825_ count_instr\[60\] _03687_ net1000 VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__o21ai_1
XFILLER_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_04968_ mem_do_rinst reg_pc\[1\] net984 VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__and3_1
X_07756_ count_instr\[34\] count_instr\[33\] _03642_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__and3_1
XFILLER_84_499 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06707_ cpuregs\[0\]\[14\] cpuregs\[1\]\[14\] cpuregs\[2\]\[14\] cpuregs\[3\]\[14\]
+ net791 net754 VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__mux4_1
X_09426_ net263 net1859 net398 VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__mux2_1
X_07687_ count_instr\[9\] count_instr\[8\] _03598_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__and3_1
XFILLER_53_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06638_ reg_pc\[11\] net560 _03061_ net516 net520 VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__a221o_1
XFILLER_53_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09357_ decoded_imm\[20\] net553 net401 _04840_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__o22a_1
X_06569_ cpuregs\[12\]\[9\] cpuregs\[13\]\[9\] cpuregs\[14\]\[9\] cpuregs\[15\]\[9\]
+ net774 net738 VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_117_2209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08308_ count_cycle\[16\] count_cycle\[17\] _04085_ VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__and3_1
X_09288_ net1165 net101 net485 VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__mux2_1
X_08239_ _03726_ _04027_ net686 VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_130_2409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_119_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_153_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_107_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11250_ clknet_leaf_149_clk _01291_ VGND VGND VPWR VPWR cpuregs\[22\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10201_ clknet_leaf_119_clk _00325_ VGND VGND VPWR VPWR cpuregs\[14\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_11181_ clknet_leaf_137_clk _01222_ VGND VGND VPWR VPWR cpuregs\[29\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_10132_ clknet_leaf_75_clk _00256_ VGND VGND VPWR VPWR cpuregs\[28\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_133_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_106_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_125_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_122_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10063_ clknet_leaf_47_clk _00187_ VGND VGND VPWR VPWR cpuregs\[13\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_145_2652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10965_ clknet_leaf_96_clk _01021_ VGND VGND VPWR VPWR decoded_imm\[9\] sky130_fd_sc_hd__dfxtp_2
XFILLER_71_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10896_ clknet_leaf_96_clk _00952_ VGND VGND VPWR VPWR is_compare sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_129_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_772 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_117_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_765 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold209 cpuregs\[1\]\[23\] VGND VGND VPWR VPWR net1317 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_125_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11448_ clknet_leaf_150_clk _01486_ VGND VGND VPWR VPWR cpuregs\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_98_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11379_ clknet_leaf_124_clk _01417_ VGND VGND VPWR VPWR cpuregs\[7\]\[3\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_84_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_124_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05940_ net697 net845 net207 net694 VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__a22o_1
XFILLER_39_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05871_ _02089_ _02419_ _02090_ net830 VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__a211o_1
XFILLER_94_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07610_ net1923 net309 net415 VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08590_ cpuregs\[24\]\[6\] cpuregs\[25\]\[6\] cpuregs\[26\]\[6\] cpuregs\[27\]\[6\]
+ net953 net918 VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__mux4_1
X_07541_ net317 net2140 net422 VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_93_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07472_ net1748 net323 net430 VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__mux2_1
XFILLER_34_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09211_ instr_jalr is_lb_lh_lw_lbu_lhu is_alu_reg_imm VGND VGND VPWR VPWR _04794_
+ sky130_fd_sc_hd__or3_2
XFILLER_50_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06423_ cpuregs\[2\]\[4\] cpuregs\[3\]\[4\] net787 VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__mux2_1
X_09142_ mem_rdata_q\[31\] mem_rdata_q\[30\] mem_rdata_q\[29\] VGND VGND VPWR VPWR
+ _04770_ sky130_fd_sc_hd__or3_1
X_06354_ cpuregs\[4\]\[2\] cpuregs\[5\]\[2\] cpuregs\[6\]\[2\] cpuregs\[7\]\[2\] net789
+ net752 VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__mux4_1
XFILLER_148_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05305_ count_cycle\[19\] net619 VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__or2_1
XFILLER_147_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06285_ decoded_imm_j\[19\] decoded_imm_j\[18\] VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__nor2_1
X_09073_ net691 net701 _01609_ net851 net984 VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__o221a_1
XFILLER_135_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_2117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05236_ _01760_ _01833_ net701 VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__o21a_1
X_08024_ net558 _03841_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__nor2_1
Xhold721 cpuregs\[9\]\[9\] VGND VGND VPWR VPWR net1829 sky130_fd_sc_hd__dlygate4sd3_1
Xhold710 cpuregs\[8\]\[8\] VGND VGND VPWR VPWR net1818 sky130_fd_sc_hd__dlygate4sd3_1
Xhold754 cpuregs\[24\]\[23\] VGND VGND VPWR VPWR net1862 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_112_2128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold743 cpuregs\[18\]\[19\] VGND VGND VPWR VPWR net1851 sky130_fd_sc_hd__dlygate4sd3_1
X_05167_ _01768_ _01769_ VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__nand2_1
Xhold732 cpuregs\[12\]\[7\] VGND VGND VPWR VPWR net1840 sky130_fd_sc_hd__dlygate4sd3_1
Xhold776 cpuregs\[18\]\[26\] VGND VGND VPWR VPWR net1884 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold787 cpuregs\[2\]\[18\] VGND VGND VPWR VPWR net1895 sky130_fd_sc_hd__dlygate4sd3_1
Xhold765 cpuregs\[16\]\[11\] VGND VGND VPWR VPWR net1873 sky130_fd_sc_hd__dlygate4sd3_1
Xhold798 cpuregs\[19\]\[28\] VGND VGND VPWR VPWR net1906 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09975_ clknet_leaf_90_clk _00099_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dfxtp_2
XFILLER_89_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05098_ _01701_ _01703_ _01704_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__a21o_1
X_08926_ net902 _04600_ net661 VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__o21a_1
XFILLER_69_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08857_ net903 _04531_ _04530_ net661 VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_127_2371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_2360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07808_ _03677_ _03678_ VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__nor2_1
XFILLER_85_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08788_ net894 _04469_ net666 VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__a21o_1
XFILLER_72_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_111_31 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07739_ count_instr\[27\] _03632_ count_instr\[28\] VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_140_2571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10750_ clknet_leaf_100_clk _00841_ VGND VGND VPWR VPWR decoder_pseudo_trigger sky130_fd_sc_hd__dfxtp_1
XFILLER_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10681_ clknet_leaf_123_clk _00773_ VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dfxtp_1
X_09409_ net339 net1929 net397 VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__mux2_1
XFILLER_40_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_139_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_138_276 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11302_ clknet_leaf_67_clk _01343_ VGND VGND VPWR VPWR cpuregs\[4\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_107_630 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11233_ clknet_leaf_37_clk _01274_ VGND VGND VPWR VPWR cpuregs\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_136_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_110_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_106_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11164_ clknet_leaf_26_clk _01205_ VGND VGND VPWR VPWR cpuregs\[23\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_11095_ clknet_leaf_35_clk _01146_ VGND VGND VPWR VPWR cpuregs\[24\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10115_ clknet_leaf_13_clk _00239_ VGND VGND VPWR VPWR cpuregs\[28\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10046_ clknet_leaf_146_clk _00170_ VGND VGND VPWR VPWR cpuregs\[13\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold92 net51 VGND VGND VPWR VPWR net1200 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 net150 VGND VGND VPWR VPWR net1189 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 net57 VGND VGND VPWR VPWR net1178 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_76_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10948_ clknet_leaf_93_clk _01004_ VGND VGND VPWR VPWR decoded_imm\[26\] sky130_fd_sc_hd__dfxtp_2
XFILLER_50_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10879_ clknet_leaf_31_clk _00935_ VGND VGND VPWR VPWR cpuregs\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_14_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_145_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_909 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_1 _00009_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_117_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06070_ _01624_ _02538_ _01625_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_78_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05021_ is_jalr_addi_slti_sltiu_xori_ori_andi is_lui_auipc_jal VGND VGND VPWR VPWR
+ _01639_ sky130_fd_sc_hd__nor2_1
XFILLER_6_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_99_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_113_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout519 _02721_ VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__clkbuf_2
XFILLER_99_878 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_86_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout508 _02736_ VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__clkbuf_4
X_09760_ net251 net2101 net360 VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__mux2_1
XFILLER_113_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_112_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06972_ _03378_ _03381_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_91_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09691_ net1599 net265 net367 VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__mux2_1
X_05923_ _02096_ _02470_ _02471_ net544 VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__o211a_1
X_08711_ _04387_ _04388_ net672 VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__mux2_1
XFILLER_94_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08642_ net233 net630 _04331_ _04332_ VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__o22a_1
XFILLER_39_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05854_ _02054_ _02410_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__xor2_1
X_05785_ _02147_ _02343_ VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__and2_1
XFILLER_54_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08573_ net899 _04266_ VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__or2_1
XFILLER_26_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07524_ net1241 net243 net429 VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__mux2_1
X_07455_ net1418 net256 net437 VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_122_2290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06406_ net705 net200 net508 net496 VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__a31o_1
XFILLER_148_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07386_ net265 net2055 net444 VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09125_ net2326 net549 _04764_ is_lb_lh_lw_lbu_lhu VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__a22o_1
X_06337_ cpuregs\[20\]\[1\] cpuregs\[21\]\[1\] net789 VGND VGND VPWR VPWR _02771_
+ sky130_fd_sc_hd__mux2_1
X_06268_ net568 _02702_ _02703_ _02704_ VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__a31o_1
X_09056_ net678 _04714_ _04716_ net892 VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__o211a_1
XFILLER_123_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05219_ reg_pc\[13\] decoded_imm\[13\] VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__or2_1
X_08007_ _03803_ _03815_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__nand2b_1
Xhold540 cpuregs\[24\]\[16\] VGND VGND VPWR VPWR net1648 sky130_fd_sc_hd__dlygate4sd3_1
X_06199_ _02647_ _02648_ VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__nor2_1
Xhold551 cpuregs\[19\]\[12\] VGND VGND VPWR VPWR net1659 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold562 cpuregs\[15\]\[5\] VGND VGND VPWR VPWR net1670 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold595 cpuregs\[2\]\[14\] VGND VGND VPWR VPWR net1703 sky130_fd_sc_hd__dlygate4sd3_1
Xhold573 cpuregs\[23\]\[4\] VGND VGND VPWR VPWR net1681 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold584 cpuregs\[11\]\[5\] VGND VGND VPWR VPWR net1692 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_77_539 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09958_ clknet_leaf_19_clk _00082_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dfxtp_2
XFILLER_49_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08909_ _04574_ _04583_ _04584_ net661 net897 VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_142_2611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_85_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold1240 mem_rdata_q\[6\] VGND VGND VPWR VPWR net2348 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1251 decoded_imm\[10\] VGND VGND VPWR VPWR net2359 sky130_fd_sc_hd__dlygate4sd3_1
X_09889_ net1122 VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__clkbuf_1
Xhold1262 reg_pc\[26\] VGND VGND VPWR VPWR net2370 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_73_745 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10802_ clknet_leaf_97_clk _00861_ VGND VGND VPWR VPWR instr_addi sky130_fd_sc_hd__dfxtp_1
XFILLER_72_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10733_ clknet_leaf_56_clk _00824_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dfxtp_2
XFILLER_60_439 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_149_Left_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_541 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10664_ clknet_leaf_94_clk _04888_ VGND VGND VPWR VPWR reg_out\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10595_ clknet_leaf_104_clk _00719_ VGND VGND VPWR VPWR count_cycle\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_153_2773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11216_ clknet_leaf_124_clk _01257_ VGND VGND VPWR VPWR cpuregs\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xoutput60 net60 VGND VGND VPWR VPWR mem_addr[5] sky130_fd_sc_hd__buf_2
Xoutput82 net82 VGND VGND VPWR VPWR mem_la_addr[26] sky130_fd_sc_hd__buf_2
Xoutput71 net71 VGND VGND VPWR VPWR mem_la_addr[15] sky130_fd_sc_hd__buf_2
X_11147_ clknet_leaf_73_clk _01188_ VGND VGND VPWR VPWR cpuregs\[31\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput93 net93 VGND VGND VPWR VPWR mem_la_addr[7] sky130_fd_sc_hd__buf_2
XFILLER_110_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11078_ clknet_leaf_123_clk _01129_ VGND VGND VPWR VPWR cpuregs\[24\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_10029_ clknet_leaf_35_clk _00153_ VGND VGND VPWR VPWR cpuregs\[30\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_17_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05570_ net871 net209 VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__and2_1
XFILLER_51_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07240_ net1240 net321 net458 VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__mux2_1
X_07171_ net1700 net318 net466 VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__mux2_1
XFILLER_145_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06122_ reg_out\[2\] alu_out_q\[2\] net841 VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__mux2_1
XFILLER_145_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_133_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_93_1820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_145_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_132_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06053_ _02521_ _02522_ net675 VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__mux2_1
Xfanout305 _02739_ VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__buf_2
X_05004_ reg_sh\[3\] reg_sh\[2\] VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__or2_1
XFILLER_141_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09812_ net314 net2051 net350 VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__mux2_1
Xfanout316 _02629_ VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__clkbuf_2
Xfanout327 net329 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout338 _02612_ VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__buf_1
XFILLER_87_859 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout349 net350 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__clkbuf_8
X_06955_ cpuregs\[20\]\[23\] cpuregs\[21\]\[23\] cpuregs\[22\]\[23\] cpuregs\[23\]\[23\]
+ net800 net763 VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__mux4_1
XFILLER_67_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09743_ net323 net2161 net357 VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_107_2049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05906_ net830 _02454_ _02455_ _02456_ VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__o22a_1
X_06886_ _03299_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__inv_2
X_09674_ net1365 net341 net365 VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__mux2_1
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05837_ _02066_ _02395_ VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__nor2_1
X_08625_ cpuregs\[16\]\[8\] cpuregs\[17\]\[8\] cpuregs\[18\]\[8\] cpuregs\[19\]\[8\]
+ net942 net907 VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_38_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08556_ net601 _04252_ _04253_ net629 VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_120_2249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05768_ _02158_ _02325_ VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__and2b_1
X_07507_ net1515 net318 net426 VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__mux2_1
X_08487_ net71 net1196 net408 VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__mux2_1
X_05699_ _02162_ net583 net579 _02161_ _02274_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_102_1971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07438_ net1291 net329 net434 VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__mux2_1
XFILLER_109_703 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07369_ net342 net1944 net442 VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__mux2_1
XFILLER_136_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09108_ net721 net720 net719 VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__and3b_1
XFILLER_6_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_135_2492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10380_ clknet_leaf_35_clk _00504_ VGND VGND VPWR VPWR cpuregs\[25\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_108_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09039_ _04701_ _04706_ _04707_ net898 net663 VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__a221o_1
Xhold381 cpuregs\[3\]\[11\] VGND VGND VPWR VPWR net1489 sky130_fd_sc_hd__dlygate4sd3_1
Xhold370 cpuregs\[1\]\[3\] VGND VGND VPWR VPWR net1478 sky130_fd_sc_hd__dlygate4sd3_1
Xhold392 cpuregs\[5\]\[26\] VGND VGND VPWR VPWR net1500 sky130_fd_sc_hd__dlygate4sd3_1
X_11001_ clknet_leaf_67_clk _01057_ VGND VGND VPWR VPWR cpuregs\[18\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_77_23 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_104_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout861 net185 VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__buf_2
Xfanout850 mem_do_wdata VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__clkbuf_2
Xfanout894 _00011_ VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__buf_4
Xfanout872 net176 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__buf_2
Xfanout883 net193 VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__buf_2
XFILLER_133_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_734 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1092 cpuregs\[7\]\[26\] VGND VGND VPWR VPWR net2200 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1070 cpuregs\[18\]\[30\] VGND VGND VPWR VPWR net2178 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1081 cpuregs\[11\]\[1\] VGND VGND VPWR VPWR net2189 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_147_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10716_ clknet_leaf_132_clk _00807_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfxtp_4
X_10647_ clknet_leaf_91_clk _00771_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dfxtp_1
XFILLER_139_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10578_ clknet_leaf_63_clk _00702_ VGND VGND VPWR VPWR reg_next_pc\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_58_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_107_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_123_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_71_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_68_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_110_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06740_ reg_pc\[15\] net561 _03159_ net518 net521 VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__a221o_1
XFILLER_49_572 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_76_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06671_ _03090_ _03092_ VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__nand2_1
XFILLER_64_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08410_ count_cycle\[55\] _04151_ net998 VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__o21ai_1
X_05622_ net209 net871 VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__nand2b_1
XFILLER_64_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09390_ net835 decoded_imm_j\[4\] _04825_ mem_rdata_q\[11\] net551 VGND VGND VPWR
+ VPWR _04858_ sky130_fd_sc_hd__a221o_1
X_08341_ _04109_ net993 _04108_ VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__and3b_1
X_05553_ net877 net233 VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__nand2_1
XFILLER_149_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05484_ net862 net216 VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__or2_1
X_08272_ _04065_ _04066_ VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__nor2_1
X_07223_ net1211 net250 net464 VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__mux2_1
XFILLER_20_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_138_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07154_ net194 _03558_ net307 VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__mux2_1
X_07085_ net187 net511 net490 _03491_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__o211a_1
X_06105_ _02571_ _02572_ net674 VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__mux2_1
X_06036_ decoded_imm_j\[15\] _01109_ net332 VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__mux2_1
XFILLER_99_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_114_783 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_818 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07987_ _03782_ _03806_ _03807_ _03794_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__o211a_1
X_09726_ net257 net1500 net363 VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__mux2_1
X_06938_ decoded_imm\[23\] net859 VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__nor2_1
XFILLER_74_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06869_ cpuregs\[8\]\[20\] cpuregs\[9\]\[20\] cpuregs\[10\]\[20\] cpuregs\[11\]\[20\]
+ net792 net755 VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__mux4_1
X_09657_ net263 net2014 net370 VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__mux2_1
X_09588_ net1263 net278 net378 VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__mux2_1
XFILLER_103_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08608_ cpuregs\[28\]\[7\] cpuregs\[29\]\[7\] cpuregs\[30\]\[7\] cpuregs\[31\]\[7\]
+ net943 net908 VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__mux4_1
X_08539_ cpuregs\[12\]\[1\] cpuregs\[13\]\[1\] cpuregs\[14\]\[1\] cpuregs\[15\]\[1\]
+ net955 net920 VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__mux4_1
XFILLER_129_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10501_ clknet_leaf_105_clk _00625_ VGND VGND VPWR VPWR count_instr\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11481_ clknet_leaf_2_clk _01519_ VGND VGND VPWR VPWR cpuregs\[10\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_137_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10432_ clknet_leaf_3_clk _00556_ VGND VGND VPWR VPWR cpuregs\[17\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_150_2732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10363_ clknet_leaf_125_clk _00487_ VGND VGND VPWR VPWR cpuregs\[25\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_152_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10294_ clknet_leaf_80_clk _00418_ VGND VGND VPWR VPWR cpuregs\[15\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_78_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_144_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_120_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_120_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout680 net681 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__clkbuf_4
XFILLER_59_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout691 _01549_ VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__buf_4
XFILLER_74_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_545 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_115_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_143_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_88_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08890_ _04558_ _04559_ _04563_ _04564_ net681 net666 VGND VGND VPWR VPWR _04567_
+ sky130_fd_sc_hd__mux4_1
X_07910_ net603 _03736_ _03737_ net503 net1227 VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__a32o_1
X_07841_ _02589_ reg_next_pc\[3\] net570 VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__mux2_1
XFILLER_111_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07772_ count_instr\[40\] count_instr\[39\] _03652_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_88_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06723_ net609 _03142_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__nor2_1
X_04984_ net701 _01605_ VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__nand2_1
X_09511_ net1724 net323 net385 VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__mux2_1
XFILLER_80_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06654_ cpuregs\[28\]\[12\] cpuregs\[29\]\[12\] cpuregs\[30\]\[12\] cpuregs\[31\]\[12\]
+ net779 net743 VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__mux4_1
XFILLER_52_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09442_ net339 net2143 net393 VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__mux2_1
XFILLER_80_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09373_ decoded_imm\[12\] net555 _04827_ _04848_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__o22a_1
X_06585_ net875 net303 VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__and2_1
X_05605_ net886 _01562_ _02184_ VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__a21o_1
X_05536_ _02078_ _02109_ _02115_ VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__or3_2
X_08324_ count_cycle\[22\] count_cycle\[23\] _04095_ VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__and3_1
XFILLER_33_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_149_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08255_ _03728_ _04049_ VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__or2_1
X_05467_ net868 net211 VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__nor2_1
XFILLER_119_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08186_ _03989_ _03990_ VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_104_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05398_ net703 net343 _01979_ _01983_ VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__a31o_1
X_07206_ net1302 net322 net462 VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_132_2440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_119_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_118_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_118_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07137_ net498 _03459_ _03541_ _03540_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__a31o_1
XFILLER_134_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_132_2451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07068_ net642 _03475_ net639 VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__a21o_1
XFILLER_121_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06019_ reg_out\[30\] reg_next_pc\[30\] net575 VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_7_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_113_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_74_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10981_ clknet_leaf_151_clk _01037_ VGND VGND VPWR VPWR cpuregs\[18\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_09709_ net326 net2130 net361 VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__mux2_1
XFILLER_130_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_129_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_122_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11464_ clknet_leaf_53_clk _01502_ VGND VGND VPWR VPWR cpuregs\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_10415_ clknet_leaf_45_clk _00539_ VGND VGND VPWR VPWR cpuregs\[20\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_109_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11395_ clknet_leaf_25_clk _01433_ VGND VGND VPWR VPWR cpuregs\[7\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_125_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10346_ clknet_leaf_34_clk _00470_ VGND VGND VPWR VPWR cpuregs\[16\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10277_ clknet_leaf_10_clk _00401_ VGND VGND VPWR VPWR cpuregs\[15\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_105_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_131_Left_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_93_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xpicorv32_1009 VGND VGND VPWR VPWR picorv32_1009/HI eoi[6] sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_140_Left_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06370_ _02794_ _02802_ net526 net517 VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__o211a_1
X_05321_ _01905_ _01906_ _01912_ VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__o21bai_1
XFILLER_147_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08040_ net688 reg_next_pc\[13\] net545 _03709_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__a22o_1
X_05252_ _01844_ _01847_ net344 net701 VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__o211a_1
Xhold903 cpuregs\[11\]\[18\] VGND VGND VPWR VPWR net2011 sky130_fd_sc_hd__dlygate4sd3_1
Xhold936 cpuregs\[19\]\[27\] VGND VGND VPWR VPWR net2044 sky130_fd_sc_hd__dlygate4sd3_1
Xhold914 cpuregs\[17\]\[21\] VGND VGND VPWR VPWR net2022 sky130_fd_sc_hd__dlygate4sd3_1
X_05183_ _01760_ _01784_ net701 VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__o21a_1
Xhold925 cpuregs\[16\]\[0\] VGND VGND VPWR VPWR net2033 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_142_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold969 cpuregs\[19\]\[22\] VGND VGND VPWR VPWR net2077 sky130_fd_sc_hd__dlygate4sd3_1
Xhold947 cpuregs\[9\]\[24\] VGND VGND VPWR VPWR net2055 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold958 cpuregs\[4\]\[19\] VGND VGND VPWR VPWR net2066 sky130_fd_sc_hd__dlygate4sd3_1
X_09991_ clknet_leaf_21_clk _00115_ VGND VGND VPWR VPWR cpuregs\[12\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_08942_ cpuregs\[12\]\[25\] cpuregs\[13\]\[25\] cpuregs\[14\]\[25\] cpuregs\[15\]\[25\]
+ net969 net934 VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__mux4_1
XFILLER_130_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_110_2089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08873_ _04545_ _04546_ net679 VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__mux2_1
XFILLER_111_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07824_ _03687_ _03688_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__nor2_1
XFILLER_84_434 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_84_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_04967_ net850 net851 net884 net888 _01592_ VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__o221a_1
X_07755_ count_instr\[33\] _03642_ count_instr\[34\] VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__a21o_1
X_06706_ cpuregs\[4\]\[14\] cpuregs\[5\]\[14\] cpuregs\[6\]\[14\] cpuregs\[7\]\[14\]
+ net780 net744 VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__mux4_1
X_07686_ count_instr\[8\] _03598_ count_instr\[9\] VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__a21o_1
X_09425_ net267 net2224 net399 VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__mux2_1
XFILLER_13_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06637_ _03057_ _03058_ _03059_ _03060_ net726 net638 VGND VGND VPWR VPWR _03061_
+ sky130_fd_sc_hd__mux4_2
XFILLER_53_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09356_ mem_rdata_q\[20\] net615 VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__and2_1
X_06568_ net488 _02915_ _02993_ net523 VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__a31o_1
XFILLER_138_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05519_ _02097_ _02098_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__or2_1
X_08307_ count_cycle\[16\] _04085_ count_cycle\[17\] VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__a21o_1
X_06499_ _02921_ _02922_ net645 VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__mux2_1
X_09287_ net1157 net100 net483 VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__mux2_1
X_08238_ _03726_ _04027_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__nand2_1
XFILLER_20_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08169_ net991 _03975_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__and2_1
XFILLER_106_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10200_ clknet_leaf_15_clk _00324_ VGND VGND VPWR VPWR cpuregs\[14\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11180_ clknet_leaf_23_clk _01221_ VGND VGND VPWR VPWR cpuregs\[23\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_10131_ clknet_leaf_64_clk _00255_ VGND VGND VPWR VPWR cpuregs\[28\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10062_ clknet_leaf_46_clk _00186_ VGND VGND VPWR VPWR cpuregs\[13\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_130_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_145_2653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10964_ clknet_leaf_96_clk _01020_ VGND VGND VPWR VPWR decoded_imm\[10\] sky130_fd_sc_hd__dfxtp_2
XFILLER_55_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10895_ clknet_leaf_103_clk _00951_ VGND VGND VPWR VPWR is_alu_reg_reg sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_129_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_784 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_144_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_777 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11447_ clknet_leaf_152_clk _01485_ VGND VGND VPWR VPWR cpuregs\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_601 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11378_ clknet_leaf_122_clk _01416_ VGND VGND VPWR VPWR cpuregs\[7\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10329_ clknet_leaf_119_clk _00453_ VGND VGND VPWR VPWR cpuregs\[16\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05870_ _02422_ _02423_ _02425_ VGND VGND VPWR VPWR alu_out\[24\] sky130_fd_sc_hd__o21ai_1
XFILLER_93_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_68_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07540_ net321 net1873 net422 VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__mux2_1
XFILLER_35_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07471_ net1265 net328 net430 VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__mux2_1
X_06422_ net649 _02850_ _02852_ VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__a21o_1
X_09210_ net1276 _01105_ net330 VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__mux2_1
X_09141_ mem_rdata_q\[28\] mem_rdata_q\[27\] mem_rdata_q\[26\] mem_rdata_q\[25\] VGND
+ VGND VPWR VPWR _04769_ sky130_fd_sc_hd__or4_2
X_06353_ net886 _02786_ net305 VGND VGND VPWR VPWR _00070_ sky130_fd_sc_hd__mux2_1
X_05304_ count_instr\[19\] net822 net623 _01896_ VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__a211o_1
XFILLER_30_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09072_ net712 latched_branch net718 net978 _04736_ VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__o311a_1
XFILLER_148_789 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_428 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_135_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06284_ decoded_imm_j\[17\] decoded_imm_j\[16\] decoded_imm_j\[15\] VGND VGND VPWR
+ VPWR _02719_ sky130_fd_sc_hd__nor3_1
X_08023_ _03837_ _03838_ _03840_ net832 VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_146_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold700 cpuregs\[24\]\[24\] VGND VGND VPWR VPWR net1808 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_112_2118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold711 cpuregs\[13\]\[14\] VGND VGND VPWR VPWR net1819 sky130_fd_sc_hd__dlygate4sd3_1
X_05235_ net6 _01653_ _01654_ net24 _01761_ VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__o221a_1
Xhold722 cpuregs\[20\]\[28\] VGND VGND VPWR VPWR net1830 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_112_2129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold755 cpuregs\[29\]\[17\] VGND VGND VPWR VPWR net1863 sky130_fd_sc_hd__dlygate4sd3_1
Xhold733 cpuregs\[19\]\[17\] VGND VGND VPWR VPWR net1841 sky130_fd_sc_hd__dlygate4sd3_1
X_05166_ reg_pc\[9\] decoded_imm\[9\] VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__or2_1
Xhold744 cpuregs\[7\]\[7\] VGND VGND VPWR VPWR net1852 sky130_fd_sc_hd__dlygate4sd3_1
Xhold788 cpuregs\[3\]\[26\] VGND VGND VPWR VPWR net1896 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold766 cpuregs\[27\]\[19\] VGND VGND VPWR VPWR net1874 sky130_fd_sc_hd__dlygate4sd3_1
Xhold777 cpuregs\[10\]\[3\] VGND VGND VPWR VPWR net1885 sky130_fd_sc_hd__dlygate4sd3_1
Xhold799 cpuregs\[27\]\[22\] VGND VGND VPWR VPWR net1907 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_130_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09974_ clknet_leaf_90_clk _00098_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dfxtp_1
XFILLER_89_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05097_ _01701_ _01703_ _01704_ VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__and3_1
X_08925_ cpuregs\[0\]\[24\] cpuregs\[1\]\[24\] cpuregs\[2\]\[24\] cpuregs\[3\]\[24\]
+ net967 net932 VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__mux4_1
XFILLER_112_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08856_ _04525_ _04526_ net679 VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_127_2361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07807_ net2316 _03676_ net997 VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__o21ai_1
XFILLER_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08787_ net680 _04462_ _04461_ net662 VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__o211a_1
X_05999_ reg_out\[20\] reg_next_pc\[20\] net572 VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__mux2_1
XFILLER_57_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_629 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07738_ net2249 _03632_ _03634_ VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_140_2572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07669_ net2307 _03589_ _03590_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__a21oi_1
X_10680_ clknet_leaf_122_clk _00772_ VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dfxtp_1
X_09408_ net470 net2166 net397 VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__mux2_1
XFILLER_13_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_139_712 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09339_ decoded_imm\[29\] net554 net401 _04831_ VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_153_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11301_ clknet_leaf_53_clk _01342_ VGND VGND VPWR VPWR cpuregs\[4\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_5_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_107_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11232_ clknet_leaf_23_clk _01273_ VGND VGND VPWR VPWR cpuregs\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_4_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11163_ clknet_leaf_9_clk _01204_ VGND VGND VPWR VPWR cpuregs\[23\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_134_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10114_ clknet_leaf_15_clk _00238_ VGND VGND VPWR VPWR cpuregs\[28\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11094_ clknet_leaf_20_clk _01145_ VGND VGND VPWR VPWR cpuregs\[24\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10045_ clknet_leaf_140_clk _00169_ VGND VGND VPWR VPWR cpuregs\[13\]\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold82 net151 VGND VGND VPWR VPWR net1190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 net56 VGND VGND VPWR VPWR net1179 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold60 net163 VGND VGND VPWR VPWR net1168 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_152_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold93 cpuregs\[25\]\[28\] VGND VGND VPWR VPWR net1201 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_75_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_91_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10947_ clknet_leaf_91_clk _01003_ VGND VGND VPWR VPWR decoded_imm\[27\] sky130_fd_sc_hd__dfxtp_2
XFILLER_32_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10878_ clknet_leaf_54_clk _00934_ VGND VGND VPWR VPWR cpuregs\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_14_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_129_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_145_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_2 _00011_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_144_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_78_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05020_ _01595_ _01638_ VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__and2_1
XFILLER_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout509 net510 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__clkbuf_4
X_06971_ _03378_ _03381_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_86_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09690_ net1746 net268 net367 VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__mux2_1
X_05922_ _02096_ _02470_ VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__nand2_1
X_08710_ net672 _04391_ _04390_ net660 VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__o211a_1
X_05853_ _02408_ _02409_ net693 VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__mux2_1
X_08641_ decoded_imm\[8\] net600 net626 VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_109_2080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_94_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_82_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05784_ _02203_ _02348_ net828 VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__o21ai_1
X_08572_ cpuregs\[0\]\[5\] cpuregs\[1\]\[5\] cpuregs\[2\]\[5\] cpuregs\[3\]\[5\] net943
+ net908 VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__mux4_1
X_07523_ net1220 net250 net429 VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__mux2_1
X_07454_ net1285 net259 net437 VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_122_2291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_2280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06405_ _01626_ _02836_ VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__or2_1
XFILLER_148_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07385_ net270 net1622 net444 VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_687 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_108_406 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09124_ net549 _04763_ VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__nor2_1
X_06336_ cpuregs\[22\]\[1\] cpuregs\[23\]\[1\] net789 VGND VGND VPWR VPWR _02770_
+ sky130_fd_sc_hd__mux2_1
X_06267_ net568 _02701_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__and2b_1
X_09055_ _04712_ _04721_ _04722_ net662 net897 VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__a221o_1
Xhold530 cpuregs\[14\]\[31\] VGND VGND VPWR VPWR net1638 sky130_fd_sc_hd__dlygate4sd3_1
X_05218_ reg_pc\[13\] decoded_imm\[13\] VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__nand2_1
X_08006_ _03823_ _03824_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__nor2_1
Xhold563 cpuregs\[13\]\[23\] VGND VGND VPWR VPWR net1671 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_89_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06198_ reg_pc\[17\] reg_pc\[16\] _02640_ VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__and3_1
Xhold552 cpuregs\[28\]\[14\] VGND VGND VPWR VPWR net1660 sky130_fd_sc_hd__dlygate4sd3_1
Xhold541 cpuregs\[2\]\[12\] VGND VGND VPWR VPWR net1649 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold585 cpuregs\[20\]\[26\] VGND VGND VPWR VPWR net1693 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_103_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05149_ net705 net878 _01750_ net702 _01753_ VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__a221o_1
XFILLER_1_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold574 cpuregs\[14\]\[3\] VGND VGND VPWR VPWR net1682 sky130_fd_sc_hd__dlygate4sd3_1
Xhold596 cpuregs\[8\]\[5\] VGND VGND VPWR VPWR net1704 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09957_ clknet_leaf_18_clk _00081_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dfxtp_1
X_08908_ _04578_ _04579_ net680 VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_142_2601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_873 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1241 instr_bne VGND VGND VPWR VPWR net2349 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_57_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold1252 decoded_imm_j\[6\] VGND VGND VPWR VPWR net2360 sky130_fd_sc_hd__dlygate4sd3_1
X_09888_ net1134 VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__clkbuf_1
Xhold1230 count_cycle\[0\] VGND VGND VPWR VPWR net2338 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1263 decoded_imm\[27\] VGND VGND VPWR VPWR net2371 sky130_fd_sc_hd__dlygate4sd3_1
X_08839_ _04507_ _04508_ _04512_ _04513_ net678 net666 VGND VGND VPWR VPWR _04519_
+ sky130_fd_sc_hd__mux4_1
XFILLER_82_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10801_ clknet_leaf_98_clk _00860_ VGND VGND VPWR VPWR instr_sh sky130_fd_sc_hd__dfxtp_1
XFILLER_60_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10732_ clknet_leaf_20_clk _00823_ VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dfxtp_2
XFILLER_25_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10663_ clknet_leaf_59_clk _04887_ VGND VGND VPWR VPWR reg_out\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_139_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10594_ clknet_leaf_104_clk _00718_ VGND VGND VPWR VPWR count_cycle\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_153_2774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_126_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_141_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_107_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput50 net50 VGND VGND VPWR VPWR mem_addr[25] sky130_fd_sc_hd__buf_2
XFILLER_150_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_134_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11215_ clknet_leaf_121_clk _01256_ VGND VGND VPWR VPWR cpuregs\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xoutput61 net61 VGND VGND VPWR VPWR mem_addr[6] sky130_fd_sc_hd__buf_2
X_11146_ clknet_leaf_75_clk _01187_ VGND VGND VPWR VPWR cpuregs\[31\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput83 net83 VGND VGND VPWR VPWR mem_la_addr[27] sky130_fd_sc_hd__buf_2
Xoutput72 net72 VGND VGND VPWR VPWR mem_la_addr[16] sky130_fd_sc_hd__buf_2
XFILLER_68_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput94 net94 VGND VGND VPWR VPWR mem_la_addr[8] sky130_fd_sc_hd__buf_2
XFILLER_49_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11077_ clknet_leaf_112_clk _01128_ VGND VGND VPWR VPWR cpuregs\[24\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_10028_ clknet_leaf_35_clk _00152_ VGND VGND VPWR VPWR cpuregs\[30\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_91_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07170_ net1864 net322 net466 VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__mux2_1
X_06121_ net534 net2189 net477 VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__mux2_1
XFILLER_8_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_120_clk clknet_4_8_0_clk VGND VGND VPWR VPWR clknet_leaf_120_clk sky130_fd_sc_hd__clkbuf_8
X_06052_ cpuregs\[8\]\[2\] cpuregs\[9\]\[2\] cpuregs\[10\]\[2\] cpuregs\[11\]\[2\]
+ net955 net920 VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__mux4_1
XFILLER_126_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05003_ reg_sh\[1\] reg_sh\[0\] VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__nor2_1
XFILLER_113_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout306 net307 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_4
Xfanout317 _02629_ VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__buf_1
X_09811_ net318 net1997 net349 VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__mux2_1
Xfanout339 net340 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_2
Xfanout328 net329 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__clkbuf_2
XFILLER_98_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09742_ net326 net1549 net357 VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__mux2_1
X_06954_ cpuregs\[0\]\[23\] cpuregs\[1\]\[23\] cpuregs\[2\]\[23\] cpuregs\[3\]\[23\]
+ net800 net763 VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__mux4_1
XFILLER_100_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_124_2320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_2039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05905_ _01560_ net223 net830 VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__o21ai_1
X_06885_ _03297_ _03298_ VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__and2_1
X_09673_ net1688 net471 net365 VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__mux2_1
X_05836_ net829 _02060_ _02394_ _02393_ VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__o31a_1
XFILLER_94_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08624_ cpuregs\[20\]\[8\] cpuregs\[21\]\[8\] cpuregs\[22\]\[8\] cpuregs\[23\]\[8\]
+ net941 net906 VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_38_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05767_ _02200_ _02333_ net828 VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__o21ai_1
XFILLER_14_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08555_ decoded_imm\[1\] net601 VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__nor2_1
X_07506_ net1404 _02626_ net426 VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__mux2_1
X_08486_ net70 net1202 net408 VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__mux2_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05698_ _02163_ net578 VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_102_1961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07437_ net1514 net335 net434 VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__mux2_1
XFILLER_109_715 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_809 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07368_ net472 net2192 net442 VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__mux2_1
XFILLER_149_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_109_748 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_109_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09107_ net2324 net499 _04750_ _04755_ VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__a22o_1
X_06319_ net733 _02752_ _02751_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_135_2493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07299_ net1300 net494 net453 VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_111_clk clknet_4_10_0_clk VGND VGND VPWR VPWR clknet_leaf_111_clk sky130_fd_sc_hd__clkbuf_8
X_09038_ _04698_ _04699_ net682 VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__mux2_1
XFILLER_117_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold371 cpuregs\[2\]\[17\] VGND VGND VPWR VPWR net1479 sky130_fd_sc_hd__dlygate4sd3_1
Xhold360 cpuregs\[24\]\[19\] VGND VGND VPWR VPWR net1468 sky130_fd_sc_hd__dlygate4sd3_1
X_11000_ clknet_leaf_48_clk _01056_ VGND VGND VPWR VPWR cpuregs\[18\]\[26\] sky130_fd_sc_hd__dfxtp_1
Xhold393 cpuregs\[28\]\[20\] VGND VGND VPWR VPWR net1501 sky130_fd_sc_hd__dlygate4sd3_1
Xhold382 cpuregs\[29\]\[0\] VGND VGND VPWR VPWR net1490 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout851 mem_do_rdata VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__clkbuf_4
Xfanout840 net841 VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__buf_4
Xfanout862 net863 VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__clkbuf_2
Xfanout873 net175 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__buf_2
Xfanout884 net885 VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__clkbuf_4
XFILLER_19_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_681 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_92_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1060 cpuregs\[16\]\[3\] VGND VGND VPWR VPWR net2168 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout895 net896 VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__buf_4
Xhold1093 cpuregs\[10\]\[0\] VGND VGND VPWR VPWR net2201 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_46_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1071 cpuregs\[22\]\[6\] VGND VGND VPWR VPWR net2179 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_18_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1082 cpuregs\[24\]\[5\] VGND VGND VPWR VPWR net2190 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_61_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10715_ clknet_leaf_131_clk _00806_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfxtp_4
XFILLER_9_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10646_ clknet_leaf_89_clk _00770_ VGND VGND VPWR VPWR count_cycle\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_9_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10577_ clknet_leaf_64_clk _00701_ VGND VGND VPWR VPWR reg_next_pc\[26\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_102_clk clknet_4_11_0_clk VGND VGND VPWR VPWR clknet_leaf_102_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_10_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_115_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_114_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_96_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11129_ clknet_leaf_12_clk _01170_ VGND VGND VPWR VPWR cpuregs\[31\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_95_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06670_ decoded_imm\[13\] net873 VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__or2_1
XFILLER_37_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05621_ _02156_ _02200_ _02199_ VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__a21o_1
X_08340_ count_cycle\[28\] count_cycle\[29\] _04105_ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__and3_1
X_05552_ _02130_ _02131_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__nand2_1
XFILLER_149_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05483_ net862 net216 VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__nor2_1
X_08271_ net2327 _04064_ net982 VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__o21ai_1
X_07222_ net1576 net251 net464 VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_17_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07153_ net525 _03539_ _03542_ _03556_ _03557_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__o32a_1
X_06104_ cpuregs\[24\]\[4\] cpuregs\[25\]\[4\] cpuregs\[26\]\[4\] cpuregs\[27\]\[4\]
+ net954 net919 VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__mux4_1
XFILLER_145_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_133_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_118_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07084_ net852 _02734_ _02735_ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__a21o_1
XFILLER_133_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06035_ net2367 net7 net614 VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__mux2_1
XFILLER_87_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_114_795 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_99_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_87_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_26_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_75_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07986_ _03781_ _03793_ VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__nand2b_1
X_09725_ net262 net1765 net364 VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__mux2_1
X_06937_ net861 _03349_ net306 VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__mux2_1
XFILLER_101_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09656_ net267 net1939 net371 VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__mux2_1
XFILLER_83_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_757 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06868_ cpuregs\[12\]\[20\] cpuregs\[13\]\[20\] cpuregs\[14\]\[20\] cpuregs\[15\]\[20\]
+ net797 net760 VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__mux4_1
XFILLER_83_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_83_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08607_ cpuregs\[16\]\[7\] cpuregs\[17\]\[7\] cpuregs\[18\]\[7\] cpuregs\[19\]\[7\]
+ net942 net907 VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__mux4_1
X_09587_ net1646 net282 net378 VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__mux2_1
X_05819_ net829 _02378_ _02379_ VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__a21o_1
X_06799_ net524 _03199_ _03201_ _03202_ _03216_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__o41a_1
XFILLER_43_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08538_ cpuregs\[8\]\[1\] cpuregs\[9\]\[1\] cpuregs\[10\]\[1\] cpuregs\[11\]\[1\]
+ net957 net922 VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__mux4_1
X_08469_ net852 _04167_ _04172_ _04202_ VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__a22o_1
XFILLER_51_771 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10500_ clknet_leaf_106_clk _00624_ VGND VGND VPWR VPWR count_instr\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_149_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_137_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11480_ clknet_leaf_14_clk _01518_ VGND VGND VPWR VPWR cpuregs\[10\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_148_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_137_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_136_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10431_ clknet_leaf_151_clk _00555_ VGND VGND VPWR VPWR cpuregs\[17\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_21_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_2733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_128_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10362_ clknet_leaf_116_clk _00486_ VGND VGND VPWR VPWR cpuregs\[25\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_10293_ clknet_leaf_76_clk _00417_ VGND VGND VPWR VPWR cpuregs\[15\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_88_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_151_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_120_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_104_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold190 cpuregs\[1\]\[2\] VGND VGND VPWR VPWR net1298 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_78_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout681 net684 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__clkbuf_4
Xfanout692 _01543_ VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__clkbuf_4
Xfanout670 net671 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__clkbuf_4
XFILLER_58_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_40_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_146_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_127_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10629_ clknet_leaf_105_clk _00753_ VGND VGND VPWR VPWR count_cycle\[46\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_115_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_111_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07840_ _01618_ _03697_ net503 reg_pc\[2\] VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__a22o_1
XFILLER_56_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07771_ count_instr\[39\] _03652_ count_instr\[40\] VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_88_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06722_ _03140_ _03141_ VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__xnor2_1
X_04983_ net700 _01605_ VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__and2_1
X_09510_ net1251 net329 net385 VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06653_ cpuregs\[8\]\[12\] cpuregs\[9\]\[12\] cpuregs\[10\]\[12\] cpuregs\[11\]\[12\]
+ net778 net742 VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__mux4_1
X_09441_ net470 net1891 net393 VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__mux2_1
X_09372_ net832 decoded_imm_j\[12\] net615 net721 VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__a22o_1
X_06584_ net876 _03009_ net305 VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__mux2_1
X_05604_ net888 _01561_ _02145_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__o21a_1
X_05535_ _02050_ _02114_ VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__nand2_1
X_08323_ count_cycle\[22\] _04095_ count_cycle\[23\] VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__a21o_1
XFILLER_33_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_119_2230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_119_821 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_2241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08254_ _04052_ _04053_ net1001 VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__o21a_1
X_05466_ instr_bne is_sltiu_bltu_sltu _02045_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__or3_1
XFILLER_20_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_119_865 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08185_ net813 _03722_ VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__nor2_1
X_05397_ net590 _01981_ _01982_ net856 net708 VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__a32o_1
X_07205_ net1707 net323 net462 VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__mux2_1
XFILLER_152_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_132_2441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07136_ net853 net512 VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__or2_1
X_07067_ _03466_ _03467_ net736 VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__mux2_1
X_06018_ net853 _02511_ net636 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__mux2_1
XFILLER_0_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_102_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07969_ _03704_ _03786_ VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__and2_1
X_09708_ net335 net1757 net361 VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__mux2_1
X_10980_ clknet_leaf_146_clk _01036_ VGND VGND VPWR VPWR cpuregs\[18\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_43_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_83_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_844 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09639_ net470 net2179 net369 VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__mux2_1
XFILLER_130_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11463_ clknet_leaf_47_clk _01501_ VGND VGND VPWR VPWR cpuregs\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_139_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_128_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_137_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10414_ clknet_leaf_43_clk _00538_ VGND VGND VPWR VPWR cpuregs\[20\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11394_ clknet_leaf_32_clk _01432_ VGND VGND VPWR VPWR cpuregs\[7\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10345_ clknet_leaf_28_clk _00469_ VGND VGND VPWR VPWR cpuregs\[16\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_911 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_140_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10276_ clknet_leaf_10_clk _00400_ VGND VGND VPWR VPWR cpuregs\[15\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_543 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_373 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_148_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05320_ net703 net343 _01907_ _01911_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__a31o_1
X_05251_ latched_is_lh _01847_ _01845_ _01760_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__a211o_1
XFILLER_134_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_116_813 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold904 cpuregs\[25\]\[14\] VGND VGND VPWR VPWR net2012 sky130_fd_sc_hd__dlygate4sd3_1
X_05182_ net2 _01653_ _01654_ net19 _01761_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__o221a_1
XFILLER_127_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold915 cpuregs\[9\]\[30\] VGND VGND VPWR VPWR net2023 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_114_2160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold926 cpuregs\[9\]\[20\] VGND VGND VPWR VPWR net2034 sky130_fd_sc_hd__dlygate4sd3_1
Xhold937 cpuregs\[10\]\[8\] VGND VGND VPWR VPWR net2045 sky130_fd_sc_hd__dlygate4sd3_1
Xhold948 cpuregs\[4\]\[28\] VGND VGND VPWR VPWR net2056 sky130_fd_sc_hd__dlygate4sd3_1
X_09990_ clknet_leaf_26_clk _00114_ VGND VGND VPWR VPWR cpuregs\[12\]\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold959 cpuregs\[18\]\[4\] VGND VGND VPWR VPWR net2067 sky130_fd_sc_hd__dlygate4sd3_1
X_08941_ net904 _04614_ VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__or2_1
XFILLER_115_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_142_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08872_ net903 _04542_ net892 VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__o21a_1
X_07823_ net2299 _03686_ net1000 VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__o21ai_1
XFILLER_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_402 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_84_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_04966_ net888 net695 mem_wordsize\[0\] VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__a21o_1
X_07754_ net2275 _03642_ _03644_ VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__a21oi_1
X_06705_ cpuregs\[8\]\[14\] cpuregs\[9\]\[14\] cpuregs\[10\]\[14\] cpuregs\[11\]\[14\]
+ net780 net744 VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__mux4_1
X_07685_ net2274 _03598_ _03600_ VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__a21oi_1
X_09424_ net271 net1918 net399 VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_91_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_91_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_52_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06636_ _03049_ _03050_ net646 VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_23_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_100_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09355_ decoded_imm\[21\] net554 net401 _04839_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__o22a_1
X_06567_ net873 net515 VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__or2_1
XFILLER_52_398 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05518_ net194 net226 VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__nor2_1
X_08306_ net2269 _04085_ _04087_ VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__a21oi_1
X_09286_ net1204 net99 net485 VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__mux2_1
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06498_ _02925_ _02926_ net645 VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__mux2_1
XFILLER_121_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08237_ _04033_ _04036_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__nand2_1
X_05449_ net703 net343 _02030_ VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__and3_1
XFILLER_21_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_125_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08168_ _03585_ _03973_ _03974_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__a21o_1
X_07119_ cpuregs\[0\]\[29\] cpuregs\[1\]\[29\] cpuregs\[2\]\[29\] cpuregs\[3\]\[29\]
+ net806 net769 VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__mux4_1
X_08099_ _03909_ _03910_ VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__nand2_1
X_10130_ clknet_leaf_50_clk _00254_ VGND VGND VPWR VPWR cpuregs\[28\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_122_849 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10061_ clknet_leaf_36_clk _00185_ VGND VGND VPWR VPWR cpuregs\[13\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_125_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_645 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_130_893 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_102_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_435 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_62_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10963_ clknet_leaf_98_clk _01019_ VGND VGND VPWR VPWR decoded_imm\[11\] sky130_fd_sc_hd__dfxtp_2
XFILLER_16_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_82_clk clknet_4_14_0_clk VGND VGND VPWR VPWR clknet_leaf_82_clk sky130_fd_sc_hd__clkbuf_8
X_10894_ clknet_leaf_102_clk _00950_ VGND VGND VPWR VPWR is_alu_reg_imm sky130_fd_sc_hd__dfxtp_2
XFILLER_70_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_48_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_796 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_789 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11446_ clknet_leaf_145_clk _01484_ VGND VGND VPWR VPWR cpuregs\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_11377_ clknet_leaf_114_clk _01415_ VGND VGND VPWR VPWR cpuregs\[7\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_125_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_98_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10328_ clknet_leaf_139_clk _00452_ VGND VGND VPWR VPWR cpuregs\[16\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_10259_ clknet_leaf_66_clk _00383_ VGND VGND VPWR VPWR cpuregs\[27\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_79_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_94_799 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_81_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_73_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_73_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07470_ net1341 net337 net430 VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__mux2_1
XFILLER_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06421_ net733 _02851_ net643 VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__a21o_1
X_09140_ net2319 net549 _04764_ is_sb_sh_sw VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__a22o_1
X_06352_ net606 _02783_ _02785_ net526 _02777_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__a221o_1
X_05303_ count_instr\[51\] net817 net826 count_cycle\[51\] VGND VGND VPWR VPWR _01896_
+ sky130_fd_sc_hd__a22o_1
X_06283_ _01554_ net609 VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__nand2_2
X_09071_ net712 _04729_ _04734_ _04735_ VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__a31o_1
X_08022_ _03708_ _03832_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_96_1863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05234_ _01817_ _01821_ _01830_ VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__a21o_1
Xhold701 cpuregs\[7\]\[6\] VGND VGND VPWR VPWR net1809 sky130_fd_sc_hd__dlygate4sd3_1
Xhold712 cpuregs\[20\]\[7\] VGND VGND VPWR VPWR net1820 sky130_fd_sc_hd__dlygate4sd3_1
Xhold734 cpuregs\[11\]\[22\] VGND VGND VPWR VPWR net1842 sky130_fd_sc_hd__dlygate4sd3_1
Xhold745 cpuregs\[4\]\[21\] VGND VGND VPWR VPWR net1853 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_2119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold723 cpuregs\[17\]\[18\] VGND VGND VPWR VPWR net1831 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_96_1874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05165_ reg_pc\[9\] decoded_imm\[9\] VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__nand2_1
X_09973_ clknet_leaf_90_clk _00097_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dfxtp_1
XFILLER_1_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold767 cpuregs\[9\]\[5\] VGND VGND VPWR VPWR net1875 sky130_fd_sc_hd__dlygate4sd3_1
Xhold778 cpuregs\[19\]\[0\] VGND VGND VPWR VPWR net1886 sky130_fd_sc_hd__dlygate4sd3_1
X_05096_ _01689_ _01691_ _01690_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__a21bo_1
Xhold756 cpuregs\[12\]\[11\] VGND VGND VPWR VPWR net1864 sky130_fd_sc_hd__dlygate4sd3_1
X_08924_ net680 _04598_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__or2_1
Xhold789 cpuregs\[6\]\[30\] VGND VGND VPWR VPWR net1897 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_89_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_893 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08855_ _04524_ _04532_ _04533_ net661 net897 VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_127_2362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08786_ _04458_ _04459_ net680 VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__mux2_1
X_07806_ count_instr\[53\] count_instr\[52\] count_instr\[51\] _03672_ VGND VGND VPWR
+ VPWR _03677_ sky130_fd_sc_hd__and4_1
XFILLER_57_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07737_ count_instr\[27\] _03632_ net997 VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__o21ai_1
X_05998_ net866 _02501_ net636 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__mux2_2
XFILLER_55_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_64_clk clknet_4_13_0_clk VGND VGND VPWR VPWR clknet_leaf_64_clk sky130_fd_sc_hd__clkbuf_8
X_04949_ instr_sltu net1716 instr_bltu VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__or3_1
XFILLER_25_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_140_2573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_80_460 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07668_ count_instr\[2\] _03589_ net980 VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_9_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06619_ _03040_ _03041_ _03042_ VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__a21o_1
X_07599_ net1534 net529 net417 VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__mux2_1
X_09407_ net473 net2117 net397 VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__mux2_1
XFILLER_139_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09338_ mem_rdata_q\[29\] net616 VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__and2_1
XFILLER_41_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11300_ clknet_leaf_47_clk _01341_ VGND VGND VPWR VPWR cpuregs\[4\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_09269_ mem_do_rdata mem_do_rinst mem_state\[1\] mem_state\[0\] VGND VGND VPWR VPWR
+ _04809_ sky130_fd_sc_hd__or4b_1
XFILLER_153_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11231_ clknet_leaf_32_clk _01272_ VGND VGND VPWR VPWR cpuregs\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11162_ clknet_leaf_10_clk _01203_ VGND VGND VPWR VPWR cpuregs\[23\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10113_ clknet_leaf_151_clk _00237_ VGND VGND VPWR VPWR cpuregs\[28\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_11093_ clknet_leaf_24_clk _01144_ VGND VGND VPWR VPWR cpuregs\[24\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_121_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold50 net135 VGND VGND VPWR VPWR net1158 sky130_fd_sc_hd__dlygate4sd3_1
X_10044_ clknet_leaf_143_clk _00168_ VGND VGND VPWR VPWR cpuregs\[13\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xhold83 net52 VGND VGND VPWR VPWR net1191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 net165 VGND VGND VPWR VPWR net1180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 net157 VGND VGND VPWR VPWR net1169 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_36_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold94 net39 VGND VGND VPWR VPWR net1202 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_55_clk clknet_4_6_0_clk VGND VGND VPWR VPWR clknet_leaf_55_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_91_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10946_ clknet_leaf_91_clk _01002_ VGND VGND VPWR VPWR decoded_imm\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10877_ clknet_leaf_16_clk _00933_ VGND VGND VPWR VPWR cpuregs\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_63_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_3 _00014_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_144_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11429_ clknet_leaf_35_clk _01467_ VGND VGND VPWR VPWR cpuregs\[8\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_78_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_602 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_781 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06970_ _03379_ _03380_ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05921_ net830 _02467_ _02468_ _02469_ VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__a22o_1
X_05852_ _02056_ _02402_ _02055_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__o21ai_1
X_08640_ _04329_ _04330_ net482 _04327_ VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_109_2081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_46_clk clknet_4_7_0_clk VGND VGND VPWR VPWR clknet_leaf_46_clk sky130_fd_sc_hd__clkbuf_8
X_05783_ _02148_ _02344_ VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__nor2_1
XFILLER_47_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08571_ cpuregs\[4\]\[5\] cpuregs\[5\]\[5\] cpuregs\[6\]\[5\] cpuregs\[7\]\[5\] net943
+ net908 VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__mux4_1
X_07522_ net1439 net251 net429 VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__mux2_1
XFILLER_50_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_122_2281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07453_ net1543 net263 net436 VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06404_ net193 net881 net508 VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__mux2_1
X_07384_ net273 net2132 net444 VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_98_1903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09123_ net719 net721 net720 VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__or3b_1
XFILLER_50_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06335_ cpuregs\[16\]\[1\] cpuregs\[17\]\[1\] net789 VGND VGND VPWR VPWR _02769_
+ sky130_fd_sc_hd__mux2_1
XFILLER_135_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06266_ reg_pc\[30\] _02698_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__nand2_1
XFILLER_108_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09054_ _04717_ _04718_ net678 VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__mux2_1
X_05217_ net711 _01809_ _01810_ _01816_ VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__a31o_1
X_08005_ decoded_imm_j\[11\] _03707_ VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__nor2_1
Xhold520 cpuregs\[17\]\[12\] VGND VGND VPWR VPWR net1628 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_771 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold531 cpuregs\[28\]\[30\] VGND VGND VPWR VPWR net1639 sky130_fd_sc_hd__dlygate4sd3_1
X_06197_ reg_pc\[16\] _02640_ reg_pc\[17\] VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__a21oi_1
Xhold553 instr_lui VGND VGND VPWR VPWR net1661 sky130_fd_sc_hd__dlygate4sd3_1
Xhold542 cpuregs\[7\]\[8\] VGND VGND VPWR VPWR net1650 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold586 cpuregs\[15\]\[13\] VGND VGND VPWR VPWR net1694 sky130_fd_sc_hd__dlygate4sd3_1
X_05148_ count_cycle\[7\] net617 net589 _01752_ VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__o211a_1
Xhold564 cpuregs\[6\]\[1\] VGND VGND VPWR VPWR net1672 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold597 cpuregs\[26\]\[8\] VGND VGND VPWR VPWR net1705 sky130_fd_sc_hd__dlygate4sd3_1
Xhold575 cpuregs\[31\]\[0\] VGND VGND VPWR VPWR net1683 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_103_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09956_ clknet_leaf_134_clk _00080_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dfxtp_4
X_05079_ net589 _01686_ _01687_ _01688_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__a31o_1
X_08907_ net902 _04575_ net892 VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__o21a_1
XFILLER_131_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09887_ net1141 VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_142_2602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08838_ net666 _04516_ _04517_ _04511_ net662 VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__a221o_1
XFILLER_85_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1242 mem_rdata_q\[1\] VGND VGND VPWR VPWR net2350 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_58_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1231 _00708_ VGND VGND VPWR VPWR net2339 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1220 mem_rdata_q\[10\] VGND VGND VPWR VPWR net2328 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_142_Right_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_100_885 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_85_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1264 decoded_imm\[7\] VGND VGND VPWR VPWR net2372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1253 count_instr\[0\] VGND VGND VPWR VPWR net2361 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_37_clk clknet_4_5_0_clk VGND VGND VPWR VPWR clknet_leaf_37_clk sky130_fd_sc_hd__clkbuf_8
X_08769_ net890 _04452_ net665 VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__a21o_1
XFILLER_72_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10800_ clknet_leaf_102_clk _00859_ VGND VGND VPWR VPWR instr_sb sky130_fd_sc_hd__dfxtp_1
X_10731_ clknet_leaf_56_clk _00822_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dfxtp_4
XFILLER_14_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_655 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10662_ clknet_leaf_95_clk _04886_ VGND VGND VPWR VPWR reg_out\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10593_ clknet_leaf_104_clk _00717_ VGND VGND VPWR VPWR count_cycle\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_153_2797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_147_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11214_ clknet_leaf_121_clk _01255_ VGND VGND VPWR VPWR cpuregs\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xoutput40 net40 VGND VGND VPWR VPWR mem_addr[15] sky130_fd_sc_hd__buf_2
Xoutput51 net51 VGND VGND VPWR VPWR mem_addr[26] sky130_fd_sc_hd__buf_2
XFILLER_107_484 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput73 net73 VGND VGND VPWR VPWR mem_la_addr[17] sky130_fd_sc_hd__buf_2
X_11145_ clknet_leaf_75_clk _01186_ VGND VGND VPWR VPWR cpuregs\[31\]\[28\] sky130_fd_sc_hd__dfxtp_1
Xoutput84 net84 VGND VGND VPWR VPWR mem_la_addr[28] sky130_fd_sc_hd__buf_2
Xoutput62 net62 VGND VGND VPWR VPWR mem_addr[7] sky130_fd_sc_hd__buf_2
Xoutput95 net95 VGND VGND VPWR VPWR mem_la_addr[9] sky130_fd_sc_hd__buf_2
X_11076_ clknet_leaf_115_clk _01127_ VGND VGND VPWR VPWR cpuregs\[24\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_10027_ clknet_leaf_22_clk _00151_ VGND VGND VPWR VPWR cpuregs\[30\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_91_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_91_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_28_clk clknet_4_4_0_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_48_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10929_ clknet_leaf_32_clk _00985_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dfxtp_1
XFILLER_32_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_30_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_895 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06120_ _02585_ reg_pc\[1\] net566 VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__mux2_1
XFILLER_145_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06051_ cpuregs\[12\]\[2\] cpuregs\[13\]\[2\] cpuregs\[14\]\[2\] cpuregs\[15\]\[2\]
+ net956 net921 VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_93_1822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05002_ net609 _01622_ VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__nor2_1
XFILLER_126_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_140_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_113_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout307 _02739_ VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__clkbuf_4
Xfanout318 _02629_ VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__clkbuf_2
X_09810_ _02626_ net2085 net349 VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__mux2_1
Xfanout329 _02617_ VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__clkbuf_2
X_06953_ cpuregs\[4\]\[23\] cpuregs\[5\]\[23\] cpuregs\[6\]\[23\] cpuregs\[7\]\[23\]
+ net800 net763 VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__mux4_1
XFILLER_141_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09741_ net335 net1752 net357 VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__mux2_1
X_05904_ _02087_ _02450_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_124_2321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_2310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06884_ decoded_imm\[21\] net862 VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__nand2_1
XFILLER_95_894 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09672_ net1615 net473 net365 VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__mux2_1
X_05835_ _02061_ _02386_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__nor2_1
XFILLER_82_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_19_clk clknet_4_3_0_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08623_ net844 net630 _04313_ _04314_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__o22a_1
XFILLER_70_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05766_ _02159_ _02320_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__nor2_1
X_08554_ _04250_ _04251_ net541 _04243_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__a211o_1
X_07505_ net1623 net324 net426 VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__mux2_1
X_08485_ net69 net1212 net408 VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__mux2_1
X_05697_ _02163_ _02270_ _02271_ net544 VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__o31a_1
XFILLER_50_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_149_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07436_ net1719 net341 net434 VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_99_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07367_ net475 net1875 net442 VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__mux2_1
XFILLER_148_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_136_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_109_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09106_ net720 mem_rdata_q\[12\] mem_rdata_q\[14\] VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__and3b_2
XFILLER_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06318_ cpuregs\[12\]\[1\] cpuregs\[13\]\[1\] cpuregs\[14\]\[1\] cpuregs\[15\]\[1\]
+ net789 net752 VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__mux4_1
X_09037_ net682 _04702_ net668 VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__o21a_1
XFILLER_108_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07298_ net1480 net527 net453 VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__mux2_1
XFILLER_151_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_135_2494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06249_ reg_pc\[26\] _02682_ reg_pc\[27\] VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__a21oi_1
Xhold361 cpuregs\[23\]\[20\] VGND VGND VPWR VPWR net1469 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_104_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold350 cpuregs\[12\]\[1\] VGND VGND VPWR VPWR net1458 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_443 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold394 cpuregs\[25\]\[13\] VGND VGND VPWR VPWR net1502 sky130_fd_sc_hd__dlygate4sd3_1
Xhold372 cpuregs\[28\]\[3\] VGND VGND VPWR VPWR net1480 sky130_fd_sc_hd__dlygate4sd3_1
Xhold383 cpuregs\[28\]\[6\] VGND VGND VPWR VPWR net1491 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout830 net831 VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__clkbuf_4
Xfanout852 net195 VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__clkbuf_4
Xfanout841 latched_stalu VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
X_09939_ clknet_leaf_35_clk _00068_ VGND VGND VPWR VPWR cpuregs\[11\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xfanout863 net184 VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__buf_2
XFILLER_86_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout874 net174 VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__clkbuf_4
Xfanout885 net182 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__buf_2
Xhold1050 cpuregs\[9\]\[18\] VGND VGND VPWR VPWR net2158 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout896 _00010_ VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__buf_4
XFILLER_45_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold1094 cpuregs\[16\]\[23\] VGND VGND VPWR VPWR net2202 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1061 cpuregs\[24\]\[18\] VGND VGND VPWR VPWR net2169 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_85_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_73_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold1072 cpuregs\[7\]\[1\] VGND VGND VPWR VPWR net2180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1083 cpuregs\[11\]\[8\] VGND VGND VPWR VPWR net2191 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_45_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10714_ clknet_leaf_100_clk _00000_ VGND VGND VPWR VPWR decoder_trigger sky130_fd_sc_hd__dfxtp_1
XFILLER_9_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10645_ clknet_leaf_81_clk _00769_ VGND VGND VPWR VPWR count_cycle\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_10_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_127_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_127_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10576_ clknet_leaf_64_clk _00700_ VGND VGND VPWR VPWR reg_next_pc\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_75_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_142_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_108_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_107_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_123_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11128_ clknet_leaf_3_clk _01169_ VGND VGND VPWR VPWR cpuregs\[31\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_83_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11059_ clknet_leaf_92_clk _01110_ VGND VGND VPWR VPWR mem_rdata_q\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_64_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_92_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_92_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05620_ net206 net874 VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__and2b_1
X_05551_ net888 net847 VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__nand2_1
XFILLER_149_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05482_ _02060_ _02061_ VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__nor2_1
XFILLER_60_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08270_ count_cycle\[0\] count_cycle\[1\] count_cycle\[2\] count_cycle\[3\] VGND
+ VGND VPWR VPWR _04065_ sky130_fd_sc_hd__and4_1
X_07221_ net1461 net255 net464 VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__mux2_1
X_07152_ reg_pc\[30\] net562 net522 VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__a21o_1
XFILLER_9_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06103_ cpuregs\[28\]\[4\] cpuregs\[29\]\[4\] cpuregs\[30\]\[4\] cpuregs\[31\]\[4\]
+ net953 net918 VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__mux4_1
XFILLER_133_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07083_ _03485_ _03488_ VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__or2_1
Xclkbuf_leaf_8_clk clknet_4_1_0_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_06034_ decoded_imm_j\[4\] _01118_ net331 VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__mux2_1
XFILLER_101_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_141_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07985_ _03779_ _03794_ _03793_ VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__a21bo_1
X_09724_ net264 net1495 net364 VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__mux2_1
XFILLER_101_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06936_ net524 _03331_ _03333_ _03334_ _03348_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__o41a_1
X_09655_ net271 net2207 net371 VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__mux2_1
X_06867_ net607 _03276_ _03277_ _03281_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__a31o_1
XFILLER_83_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05818_ _02074_ _02372_ net693 _02073_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__o211a_1
XFILLER_94_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08606_ net669 _04297_ VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__or2_1
XFILLER_28_769 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09586_ net1382 net285 net378 VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__mux2_1
X_06798_ reg_pc\[17\] net561 _03215_ net518 net521 VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__a221o_1
XFILLER_15_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05749_ _02121_ _02316_ _02317_ net544 VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__o211a_1
X_08537_ net847 _04235_ net631 VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__mux2_1
X_08468_ _04200_ _04201_ _04167_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__a21oi_1
XFILLER_51_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07419_ net1563 net266 net441 VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__mux2_1
XFILLER_137_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08399_ count_cycle\[49\] count_cycle\[50\] count_cycle\[51\] _04140_ VGND VGND VPWR
+ VPWR _04146_ sky130_fd_sc_hd__and4_1
X_10430_ clknet_leaf_146_clk _00554_ VGND VGND VPWR VPWR cpuregs\[17\]\[6\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_21_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_152_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_150_2734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_137_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_124_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10361_ clknet_leaf_115_clk _00485_ VGND VGND VPWR VPWR cpuregs\[25\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_151_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10292_ clknet_leaf_71_clk _00416_ VGND VGND VPWR VPWR cpuregs\[15\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_152_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold180 cpuregs\[15\]\[7\] VGND VGND VPWR VPWR net1288 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_144_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold191 cpuregs\[24\]\[4\] VGND VGND VPWR VPWR net1299 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_78_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout660 _01557_ VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_148_2696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_144_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout682 net683 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__clkbuf_4
XFILLER_93_617 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout693 _01543_ VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__buf_2
XFILLER_65_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout671 net676 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__clkbuf_4
XFILLER_19_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_128_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10628_ clknet_leaf_105_clk _00752_ VGND VGND VPWR VPWR count_cycle\[45\] sky130_fd_sc_hd__dfxtp_1
X_10559_ clknet_leaf_133_clk _00683_ VGND VGND VPWR VPWR reg_next_pc\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_127_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_96_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_69_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_96_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_68_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_04982_ instr_sw instr_sh instr_sb _01606_ VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__or4b_1
X_07770_ net2294 _03652_ _03654_ VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_88_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06721_ decoded_imm\[14\] net872 _03117_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__a21oi_1
XFILLER_65_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09440_ net473 net2154 net393 VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__mux2_1
XFILLER_65_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06652_ cpuregs\[12\]\[12\] cpuregs\[13\]\[12\] cpuregs\[14\]\[12\] cpuregs\[15\]\[12\]
+ net778 net742 VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__mux4_1
XFILLER_37_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09371_ decoded_imm\[13\] net555 _04827_ _04847_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__o22a_1
X_06583_ _02991_ _02992_ _02994_ _03008_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__o31a_1
XFILLER_52_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05603_ net846 net883 VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__and2b_1
X_05534_ _02110_ _02112_ VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__or2_1
X_08322_ net2278 _04095_ _04097_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__a21oi_1
X_08253_ net690 reg_next_pc\[30\] net547 _03727_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_119_2242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_2231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05465_ instr_bgeu instr_bge is_slti_blt_slt VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__or3_1
X_07204_ net1280 net328 net462 VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__mux2_1
XFILLER_119_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08184_ net812 _03722_ VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__and2_1
X_05396_ count_cycle\[26\] net618 VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__or2_1
XFILLER_20_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_134_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_119_877 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07135_ net856 net512 net490 _03491_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_132_2442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_133_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07066_ net656 _03463_ _03465_ net730 VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__o211a_1
XFILLER_134_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06017_ reg_out\[29\] reg_next_pc\[29\] net575 VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__mux2_1
Xoutput230 net230 VGND VGND VPWR VPWR pcpi_rs2[5] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_7_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_102_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_101_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_87_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07968_ _03789_ _03790_ net977 VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__o21a_1
X_06919_ net856 net514 VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__or2_1
XFILLER_56_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09707_ net341 net1686 net361 VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__mux2_1
XFILLER_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07899_ reg_pc\[31\] net505 _03728_ net605 VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__a22o_1
X_09638_ net474 net2138 net369 VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__mux2_1
XFILLER_71_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09569_ net1273 net532 net380 VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_26_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_130_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_70_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_142_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_905 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_149_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11462_ clknet_leaf_40_clk _01500_ VGND VGND VPWR VPWR cpuregs\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_10413_ clknet_leaf_36_clk _00537_ VGND VGND VPWR VPWR cpuregs\[20\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_11393_ clknet_leaf_30_clk _01431_ VGND VGND VPWR VPWR cpuregs\[7\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_137_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10344_ clknet_leaf_45_clk _00468_ VGND VGND VPWR VPWR cpuregs\[16\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_124_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_99_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10275_ clknet_leaf_5_clk _00399_ VGND VGND VPWR VPWR cpuregs\[15\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_120_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_78_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout490 net491 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__clkbuf_2
XFILLER_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_93_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_45_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_385 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_62_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_61_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_119_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05250_ net7 _01653_ _01846_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__o21a_1
X_05181_ _01768_ _01772_ _01781_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__a21o_1
XFILLER_143_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold927 cpuregs\[5\]\[30\] VGND VGND VPWR VPWR net2035 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_825 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold916 cpuregs\[3\]\[31\] VGND VGND VPWR VPWR net2024 sky130_fd_sc_hd__dlygate4sd3_1
Xhold905 cpuregs\[18\]\[0\] VGND VGND VPWR VPWR net2013 sky130_fd_sc_hd__dlygate4sd3_1
Xhold938 cpuregs\[8\]\[27\] VGND VGND VPWR VPWR net2046 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_142_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_116_869 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_2161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_89_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold949 cpuregs\[5\]\[13\] VGND VGND VPWR VPWR net2057 sky130_fd_sc_hd__dlygate4sd3_1
X_08940_ cpuregs\[0\]\[25\] cpuregs\[1\]\[25\] cpuregs\[2\]\[25\] cpuregs\[3\]\[25\]
+ net969 net934 VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__mux4_1
XFILLER_131_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_103_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08871_ cpuregs\[8\]\[21\] cpuregs\[9\]\[21\] cpuregs\[10\]\[21\] cpuregs\[11\]\[21\]
+ net964 net929 VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__mux4_1
XFILLER_97_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07822_ count_instr\[59\] count_instr\[58\] count_instr\[57\] _03682_ VGND VGND VPWR
+ VPWR _03687_ sky130_fd_sc_hd__and4_1
XFILLER_69_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_84_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_04965_ net978 net2121 VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__and2_1
X_07753_ count_instr\[33\] _03642_ net979 VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__o21ai_1
X_06704_ cpuregs\[12\]\[14\] cpuregs\[13\]\[14\] cpuregs\[14\]\[14\] cpuregs\[15\]\[14\]
+ net791 net754 VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__mux4_1
X_07684_ count_instr\[8\] _03598_ net985 VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__o21ai_1
X_09423_ net276 net2084 net398 VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__mux2_1
X_06635_ _03055_ _03056_ net646 VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__mux2_1
XFILLER_44_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_09354_ mem_rdata_q\[21\] net615 VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_23_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08305_ count_cycle\[16\] _04085_ net995 VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__o21ai_1
X_06566_ net877 net506 _02913_ net495 VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__o211a_1
X_05517_ net194 net226 VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__and2_1
X_09285_ net1162 net98 net483 VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__mux2_1
X_06497_ cpuregs\[0\]\[6\] cpuregs\[1\]\[6\] cpuregs\[2\]\[6\] cpuregs\[3\]\[6\] net775
+ net739 VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__mux4_1
X_08236_ _04033_ _04036_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__or2_1
X_05448_ net24 net596 net588 VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__a21o_1
XFILLER_21_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08167_ net689 reg_next_pc\[23\] net546 _03720_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__a22o_1
XFILLER_109_11 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07118_ cpuregs\[4\]\[29\] cpuregs\[5\]\[29\] cpuregs\[6\]\[29\] cpuregs\[7\]\[29\]
+ net806 net769 VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__mux4_1
X_05379_ _01952_ _01955_ _01965_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__nand3_1
XFILLER_4_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_134_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_118_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08098_ decoded_imm_j\[18\] _03714_ VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__or2_1
XFILLER_134_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_106_368 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_07049_ _03455_ _03456_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__nor2_1
X_10060_ clknet_leaf_36_clk _00184_ VGND VGND VPWR VPWR cpuregs\[13\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_130_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_75_403 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_657 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_145_2655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_75_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10962_ clknet_leaf_96_clk _01018_ VGND VGND VPWR VPWR decoded_imm\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_897 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_71_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10893_ clknet_leaf_24_clk _00949_ VGND VGND VPWR VPWR cpuregs\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_43_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_889 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11445_ clknet_leaf_143_clk _01483_ VGND VGND VPWR VPWR cpuregs\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_11376_ clknet_leaf_14_clk _01414_ VGND VGND VPWR VPWR cpuregs\[7\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_140_625 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10327_ clknet_leaf_55_clk _00451_ VGND VGND VPWR VPWR cpuregs\[26\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_10258_ clknet_leaf_50_clk _00382_ VGND VGND VPWR VPWR cpuregs\[27\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_22_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10189_ clknet_leaf_36_clk _00313_ VGND VGND VPWR VPWR cpuregs\[9\]\[21\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_53_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06420_ cpuregs\[12\]\[4\] cpuregs\[13\]\[4\] cpuregs\[14\]\[4\] cpuregs\[15\]\[4\]
+ net785 net749 VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__mux4_1
XFILLER_35_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06351_ net517 _02760_ _02773_ net563 reg_pc\[1\] VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__a32o_1
X_06282_ net709 net607 VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__nor2_1
X_05302_ net11 net596 net588 VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_62_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09070_ net718 _01629_ net712 VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__a21oi_1
XFILLER_147_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05233_ _01817_ _01821_ _01830_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__nand3_1
X_08021_ _03708_ _03832_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__and2_1
Xhold702 cpuregs\[2\]\[22\] VGND VGND VPWR VPWR net1810 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_143_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold735 cpuregs\[30\]\[23\] VGND VGND VPWR VPWR net1843 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_104_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_96_1875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold713 cpuregs\[30\]\[19\] VGND VGND VPWR VPWR net1821 sky130_fd_sc_hd__dlygate4sd3_1
X_05164_ net711 _01758_ _01759_ _01767_ VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__a31o_1
Xhold724 cpuregs\[3\]\[7\] VGND VGND VPWR VPWR net1832 sky130_fd_sc_hd__dlygate4sd3_1
Xhold746 cpuregs\[31\]\[2\] VGND VGND VPWR VPWR net1854 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_116_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09972_ clknet_leaf_91_clk _00096_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dfxtp_2
Xhold757 cpuregs\[18\]\[17\] VGND VGND VPWR VPWR net1865 sky130_fd_sc_hd__dlygate4sd3_1
Xhold768 cpuregs\[4\]\[2\] VGND VGND VPWR VPWR net1876 sky130_fd_sc_hd__dlygate4sd3_1
Xhold779 cpuregs\[19\]\[9\] VGND VGND VPWR VPWR net1887 sky130_fd_sc_hd__dlygate4sd3_1
X_05095_ reg_pc\[4\] decoded_imm\[4\] VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__or2_1
X_08923_ cpuregs\[4\]\[24\] cpuregs\[5\]\[24\] cpuregs\[6\]\[24\] cpuregs\[7\]\[24\]
+ net965 net930 VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__mux4_1
XFILLER_103_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_103_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_112_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08854_ _04527_ _04528_ net679 VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_127_2363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08785_ _04465_ _04466_ _04467_ net893 net898 VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__a221o_1
X_05997_ reg_out\[19\] reg_next_pc\[19\] net572 VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__mux2_1
X_07805_ _03676_ net997 _03675_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__and3b_1
XFILLER_29_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07736_ _03632_ _03633_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__nor2_1
X_04948_ net816 net825 net823 VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__or3_1
XFILLER_65_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_140_2574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07667_ _03589_ net979 _03588_ VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__and3b_1
XFILLER_26_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06618_ _03013_ _03014_ _03012_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__a21bo_1
X_09406_ net493 net2067 net400 VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__mux2_1
X_07598_ net2003 net533 net417 VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__mux2_1
X_09337_ decoded_imm\[30\] net554 net401 _04830_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_80_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06549_ cpuregs\[4\]\[8\] cpuregs\[5\]\[8\] cpuregs\[6\]\[8\] cpuregs\[7\]\[8\] net773
+ net737 VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__mux4_1
X_09268_ net984 _04807_ VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__and2_1
X_08219_ _04020_ _04021_ net1002 VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__o21a_1
X_09199_ mem_rdata_q\[31\] net25 net614 VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__mux2_1
XFILLER_153_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11230_ clknet_leaf_31_clk _01271_ VGND VGND VPWR VPWR cpuregs\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11161_ clknet_leaf_7_clk _01202_ VGND VGND VPWR VPWR cpuregs\[23\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_20_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10112_ clknet_leaf_149_clk _00236_ VGND VGND VPWR VPWR cpuregs\[28\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_136_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_11092_ clknet_leaf_25_clk _01143_ VGND VGND VPWR VPWR cpuregs\[24\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_102_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold40 net152 VGND VGND VPWR VPWR net1148 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_48_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10043_ clknet_leaf_125_clk _00167_ VGND VGND VPWR VPWR cpuregs\[13\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_152_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold62 net55 VGND VGND VPWR VPWR net1170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 net59 VGND VGND VPWR VPWR net1181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 net58 VGND VGND VPWR VPWR net1159 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_152_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold95 instr_lbu VGND VGND VPWR VPWR net1203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 net61 VGND VGND VPWR VPWR net1192 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_35_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_91_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_119_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10945_ clknet_leaf_91_clk _01001_ VGND VGND VPWR VPWR decoded_imm\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_17_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10876_ clknet_leaf_29_clk _00932_ VGND VGND VPWR VPWR cpuregs\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_80_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_138_780 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_129_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 _00014_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11428_ clknet_leaf_34_clk _01466_ VGND VGND VPWR VPWR cpuregs\[8\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_78_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_153_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_128_Left_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_113_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11359_ clknet_leaf_12_clk _01397_ VGND VGND VPWR VPWR cpuregs\[6\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_98_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_793 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_112_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_91_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05920_ net830 _02097_ VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_91_1794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_05851_ _02058_ _02399_ _02213_ VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__a21oi_1
XFILLER_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_2082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_2071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08570_ net600 net541 VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__nor2_4
X_07521_ net1400 net255 net429 VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_137_Left_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05782_ _02340_ _02347_ VGND VGND VPWR VPWR alu_out\[14\] sky130_fd_sc_hd__or2_1
X_07452_ net1328 net269 net436 VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_122_2282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07383_ net277 net1999 net444 VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06403_ _02832_ _02833_ _02805_ _02808_ VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_98_1904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09122_ net719 net721 net720 VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__nor3b_1
X_06334_ cpuregs\[18\]\[1\] cpuregs\[19\]\[1\] net789 VGND VGND VPWR VPWR _02768_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_19 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_148_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_135_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06265_ reg_pc\[30\] _02698_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__or2_1
X_09053_ net902 _04713_ net893 VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__o21a_1
Xhold510 cpuregs\[2\]\[30\] VGND VGND VPWR VPWR net1618 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06196_ reg_out\[17\] alu_out_q\[17\] net842 VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__mux2_1
X_05216_ net706 net874 _01812_ net702 _01815_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__a221o_1
X_08004_ decoded_imm_j\[11\] _03707_ VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__and2_1
XFILLER_144_783 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold532 cpuregs\[20\]\[23\] VGND VGND VPWR VPWR net1640 sky130_fd_sc_hd__dlygate4sd3_1
Xhold543 cpuregs\[15\]\[20\] VGND VGND VPWR VPWR net1651 sky130_fd_sc_hd__dlygate4sd3_1
X_05147_ net824 count_cycle\[39\] net622 _01751_ VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__a211o_1
Xhold521 cpuregs\[9\]\[2\] VGND VGND VPWR VPWR net1629 sky130_fd_sc_hd__dlygate4sd3_1
Xhold554 cpuregs\[7\]\[11\] VGND VGND VPWR VPWR net1662 sky130_fd_sc_hd__dlygate4sd3_1
Xhold576 cpuregs\[15\]\[21\] VGND VGND VPWR VPWR net1684 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_116_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold587 cpuregs\[4\]\[20\] VGND VGND VPWR VPWR net1695 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_103_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold565 cpuregs\[20\]\[10\] VGND VGND VPWR VPWR net1673 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_129_2403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09955_ clknet_leaf_135_clk _00079_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dfxtp_2
Xhold598 cpuregs\[3\]\[6\] VGND VGND VPWR VPWR net1706 sky130_fd_sc_hd__dlygate4sd3_1
X_05078_ net707 net883 _01678_ net700 _01684_ VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__a221o_1
X_08906_ cpuregs\[8\]\[23\] cpuregs\[9\]\[23\] cpuregs\[10\]\[23\] cpuregs\[11\]\[23\]
+ net967 net932 VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__mux4_1
XFILLER_100_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09886_ net1136 VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_142_2603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_111_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold1210 count_instr\[57\] VGND VGND VPWR VPWR net2318 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_853 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_08837_ net678 _04509_ net897 VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__o21a_1
Xhold1221 mem_rdata_q\[17\] VGND VGND VPWR VPWR net2329 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1243 net169 VGND VGND VPWR VPWR net2351 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1232 instr_sh VGND VGND VPWR VPWR net2340 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_100_897 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold1265 reg_pc\[20\] VGND VGND VPWR VPWR net2373 sky130_fd_sc_hd__dlygate4sd3_1
Xhold1254 instr_lh VGND VGND VPWR VPWR net2362 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08768_ _04441_ _04442_ net673 VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__mux2_1
X_07719_ count_instr\[21\] count_instr\[20\] VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__and2_1
XFILLER_72_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08699_ cpuregs\[16\]\[12\] cpuregs\[17\]\[12\] cpuregs\[18\]\[12\] cpuregs\[19\]\[12\]
+ net946 net911 VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__mux4_1
X_10730_ clknet_leaf_21_clk _00821_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dfxtp_2
XFILLER_14_837 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10661_ clknet_leaf_95_clk _04885_ VGND VGND VPWR VPWR reg_out\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_45_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_45_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_881 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10592_ clknet_leaf_104_clk _00716_ VGND VGND VPWR VPWR count_cycle\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_153_2776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11213_ clknet_leaf_14_clk _01254_ VGND VGND VPWR VPWR cpuregs\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xoutput52 net52 VGND VGND VPWR VPWR mem_addr[27] sky130_fd_sc_hd__buf_2
XFILLER_107_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput41 net41 VGND VGND VPWR VPWR mem_addr[16] sky130_fd_sc_hd__buf_2
X_11144_ clknet_leaf_64_clk _01185_ VGND VGND VPWR VPWR cpuregs\[31\]\[27\] sky130_fd_sc_hd__dfxtp_1
Xoutput85 net85 VGND VGND VPWR VPWR mem_la_addr[29] sky130_fd_sc_hd__buf_2
Xoutput74 net74 VGND VGND VPWR VPWR mem_la_addr[18] sky130_fd_sc_hd__buf_2
XFILLER_68_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput63 net63 VGND VGND VPWR VPWR mem_addr[8] sky130_fd_sc_hd__buf_2
XFILLER_1_741 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_122_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_785 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput96 net96 VGND VGND VPWR VPWR mem_la_read sky130_fd_sc_hd__buf_2
X_11075_ clknet_leaf_140_clk _01126_ VGND VGND VPWR VPWR cpuregs\[24\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_10026_ clknet_leaf_25_clk _00150_ VGND VGND VPWR VPWR cpuregs\[30\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_76_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_10928_ clknet_leaf_30_clk _00984_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dfxtp_1
XFILLER_32_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10859_ clknet_leaf_96_clk net1416 VGND VGND VPWR VPWR is_slti_blt_slt sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_841 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_145_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_06050_ _02518_ _02519_ net675 VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_93_1823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05001_ mem_do_prefetch _01603_ VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__or2_1
XFILLER_141_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout308 net311 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__clkbuf_2
Xfanout319 _02629_ VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlymetal6s2s_1
X_06952_ cpuregs\[8\]\[23\] cpuregs\[9\]\[23\] cpuregs\[10\]\[23\] cpuregs\[11\]\[23\]
+ net801 net764 VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__mux4_1
XFILLER_141_797 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_113_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_100_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09740_ net340 net1663 net357 VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__mux2_1
.ends
